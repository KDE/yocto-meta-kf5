# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "f8f3e8ce6e434b1f4b9fc7071e954214bae9a8ef"
