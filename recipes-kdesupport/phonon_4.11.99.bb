# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

# this is some arbitrary hash picked for compatibility with Qt6
require ${PN}.inc
SRCREV = "d3174600721d803a53e0433ad87ed6a7f4ba99e7"
PR = "0"
