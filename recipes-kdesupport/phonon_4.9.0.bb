require ${PN}.inc
# v4.9.0 misses a build fix we need, so use a newer revision until there's a newer release
# SRCREV = "v${PV}"
SRCREV = "543183aa844a27869c7fc46957ff097c155d6575"
