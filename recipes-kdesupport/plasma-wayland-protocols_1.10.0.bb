# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "78fc6ee77334a147986f01c6d3c6e1b99af1a333"
