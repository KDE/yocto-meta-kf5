# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "2af42fb090538c77c33721f1d39ae5ab99870e5c"
