# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "c95844003cf5e6d3bb74750ecd2c923692fc75da"
