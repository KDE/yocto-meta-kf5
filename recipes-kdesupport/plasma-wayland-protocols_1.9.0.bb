# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "ab8fbdd16f19842078e5b9cff81d9e6df6d3cf49"
