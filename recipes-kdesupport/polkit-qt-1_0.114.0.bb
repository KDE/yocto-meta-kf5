# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "ccab85232550419100207ed61fe1bbbb35c112ff"
