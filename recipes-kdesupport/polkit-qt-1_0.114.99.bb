# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

# this is just a hash from the master branch but it compiles with Qt6
require ${PN}.inc
SRCREV = "590e7108acf4e2ccb3d2d95e6c436054e310e756"
