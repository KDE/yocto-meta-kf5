# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/portingAids/kdelibs4support-5.101.0.tar.xz"
SRC_URI[sha256sum] = "75b22a61e5341c91dfb59d1a601a6f7b989be0185a707dcfb489910940ee4aaa"

