# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/portingAids/kdelibs4support-5.102.0.tar.xz"
SRC_URI[sha256sum] = "643ef6b24b4fc6c06882f2a00ac7bc6a5c7f11811be152b012879ec7591d0269"

