# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/portingAids/kdelibs4support-5.103.0.tar.xz"
SRC_URI[sha256sum] = "fbc2a980a2c5a50400b4bda3a1d11d54384934f49d9a444292a7204c5411f853"

