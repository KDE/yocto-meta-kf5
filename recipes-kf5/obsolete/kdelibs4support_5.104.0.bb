# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/portingAids/kdelibs4support-5.104.0.tar.xz"
SRC_URI[sha256sum] = "9baab7823864ce05917c09126187dbca8a66f69669ddcacf8bb3d3a68c3935f2"

