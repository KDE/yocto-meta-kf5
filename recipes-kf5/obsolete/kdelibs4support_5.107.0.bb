# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/portingAids/kdelibs4support-5.107.0.tar.xz"
SRC_URI[sha256sum] = "ef94568b687230734725d2a74108ff869c0beeb6d3476503265719e182660c8f"

