# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/portingAids/kdelibs4support-5.110.0.tar.xz"
SRC_URI[sha256sum] = "c42931af396a5d089a626cf6a23a0e94d18e567a9766ea4afe5318e400833085"

