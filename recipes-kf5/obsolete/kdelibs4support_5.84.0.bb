# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/portingAids/kdelibs4support-5.84.0.tar.xz"
SRC_URI[sha256sum] = "373f46d34b04cb6faeca577eaa67472a630b312af59d5851880623ecc0c671e2"

