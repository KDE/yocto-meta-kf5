# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/portingAids/kdelibs4support-5.85.0.tar.xz"
SRC_URI[sha256sum] = "a0d6232601b11995d68a6c178c390bf9d201df9148509bc2d938d0a381699fb0"

