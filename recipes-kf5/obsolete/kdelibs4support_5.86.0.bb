# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/portingAids/kdelibs4support-5.86.0.tar.xz"
SRC_URI[sha256sum] = "901d001d15c4963fd0b2431c823a038d3b0ea6333dbdcb27117deb6979dc42eb"

