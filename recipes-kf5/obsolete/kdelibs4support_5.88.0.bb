# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/portingAids/kdelibs4support-5.88.0.tar.xz"
SRC_URI[sha256sum] = "e680c437cb94cda65d54eea228bd3a652b45031c0ba2e1a7b0ee4810be298245"

