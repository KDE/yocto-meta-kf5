# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/portingAids/kdelibs4support-5.89.0.tar.xz"
SRC_URI[sha256sum] = "7969f37808ebde51222d39dc3b9fad5a8f4addfbd6efd421cead72e0ca71e298"

