# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/portingAids/kdelibs4support-5.90.0.tar.xz"
SRC_URI[sha256sum] = "49ccf1989eb66f06414b62aeca9c82e35c6906e5a66549d3f9d880b76408ac7f"

