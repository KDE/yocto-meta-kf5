# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/portingAids/kdelibs4support-5.93.0.tar.xz"
SRC_URI[sha256sum] = "6a3e1d80cc6babc12930f24f9afd1ed10b46ae58ea71d44a466178212b07377c"

