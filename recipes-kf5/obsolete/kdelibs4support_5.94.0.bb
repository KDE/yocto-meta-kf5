# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/portingAids/kdelibs4support-5.94.0.tar.xz"
SRC_URI[sha256sum] = "d726ebb00766d3d5ed39603601c4b9541659bebc4bb7b755eec25bffd8a76033"

