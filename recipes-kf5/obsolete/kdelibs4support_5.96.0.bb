# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/portingAids/kdelibs4support-5.96.0.tar.xz"
SRC_URI[sha256sum] = "a7268e00b0691d930d69e86970c5300a98d8657f13d181dfcc35fcf0c24bc9a1"

