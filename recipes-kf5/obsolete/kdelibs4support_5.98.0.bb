# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/portingAids/kdelibs4support-5.98.0.tar.xz"
SRC_URI[sha256sum] = "0ead944e9ada2adf8fde2724762dcb6ee265e6aa368b94b3147ce6c062cfde43"

