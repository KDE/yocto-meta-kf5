# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/portingAids/kdelibs4support-5.99.0.tar.xz"
SRC_URI[sha256sum] = "0535c7ca1184e7d75e28c630911b640e533782120691510217b293a8143e8d1c"

