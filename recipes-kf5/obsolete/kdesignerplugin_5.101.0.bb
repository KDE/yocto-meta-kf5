# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/portingAids/kdesignerplugin-5.101.0.tar.xz"
SRC_URI[sha256sum] = "7a67b5a56df3c7a9279392b8aae3ccd26c5bed83ab0bff4cbbca84501abed986"

