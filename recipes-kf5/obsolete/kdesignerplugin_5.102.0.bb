# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/portingAids/kdesignerplugin-5.102.0.tar.xz"
SRC_URI[sha256sum] = "6ce58872dfc76bc2464e4f09510772cc09b233645601ac9e8816134b2570c2da"

