# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/portingAids/kdesignerplugin-5.103.0.tar.xz"
SRC_URI[sha256sum] = "1c52d7cd61e3404bb83f14be533b2c825e29599484b0b16733d852117eab3aca"

