# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/portingAids/kdesignerplugin-5.104.0.tar.xz"
SRC_URI[sha256sum] = "bc9b0244f37938683d9e7dd622ff853a9b757cefcbc0f0f257e99443f2968183"

