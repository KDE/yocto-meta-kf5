# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/portingAids/kdesignerplugin-5.105.0.tar.xz"
SRC_URI[sha256sum] = "e7482e698c2b2d8550ab8fb54b30f72ec363ff92e082f20a856e02b337d4aa66"

