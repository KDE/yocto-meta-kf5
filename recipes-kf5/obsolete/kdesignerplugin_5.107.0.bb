# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/portingAids/kdesignerplugin-5.107.0.tar.xz"
SRC_URI[sha256sum] = "688dc43ec37de6a24848410593f17034e56be1659efe00c46fd31fedbc77be53"

