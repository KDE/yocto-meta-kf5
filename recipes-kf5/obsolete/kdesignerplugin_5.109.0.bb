# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/portingAids/kdesignerplugin-${PV}.tar.xz"
SRC_URI[sha256sum] = "2dc1a83d7c9e14aab7e9140767e89f754f769fa951e9b40def28f13c2190cb29"

