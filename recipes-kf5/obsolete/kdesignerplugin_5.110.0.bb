# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/portingAids/kdesignerplugin-5.110.0.tar.xz"
SRC_URI[sha256sum] = "cc124e9e0a867b62175ca280afb96f61d8862246e40314fa0050aa9c9345d190"

