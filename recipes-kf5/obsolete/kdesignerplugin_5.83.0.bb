# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/portingAids/kdesignerplugin-5.83.0.tar.xz"
SRC_URI[sha256sum] = "203ff1989d7c076498d442698e8e70d158fb69094d056e18100ac74e064a0c8d"

