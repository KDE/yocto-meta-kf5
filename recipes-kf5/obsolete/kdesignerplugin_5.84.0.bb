# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/portingAids/kdesignerplugin-5.84.0.tar.xz"
SRC_URI[sha256sum] = "5d091b325862b41eda9eecaecc4165db45078c507a5dc0e742cc3502a7bca14c"

