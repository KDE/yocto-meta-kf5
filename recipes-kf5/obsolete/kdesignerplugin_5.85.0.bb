# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/portingAids/kdesignerplugin-5.85.0.tar.xz"
SRC_URI[sha256sum] = "8ed96e2927d5b954ceb48c5f1d69e94d4439af987f5911489b55e4e3eb76905d"

