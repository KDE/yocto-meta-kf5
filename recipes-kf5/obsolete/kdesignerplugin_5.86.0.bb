# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/portingAids/kdesignerplugin-5.86.0.tar.xz"
SRC_URI[sha256sum] = "b4c35a1c5a3f62de0f728dde64142e811e01dd0bcb0605cf68924d17b3896e90"

