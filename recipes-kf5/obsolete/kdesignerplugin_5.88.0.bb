# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/portingAids/kdesignerplugin-5.88.0.tar.xz"
SRC_URI[sha256sum] = "d90c6245209d52e891755fcf8a35ce40d9de3b9c315c3f4bef8b556270b0154b"

