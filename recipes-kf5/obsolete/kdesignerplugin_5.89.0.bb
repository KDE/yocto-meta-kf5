# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/portingAids/kdesignerplugin-5.89.0.tar.xz"
SRC_URI[sha256sum] = "6e4324e9fb3ae42c6eb0abddd607250de953e2b4d8e324903f1a557062281e3d"

