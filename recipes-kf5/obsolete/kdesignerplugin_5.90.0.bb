# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/portingAids/kdesignerplugin-5.90.0.tar.xz"
SRC_URI[sha256sum] = "388a2e9a2be330c7e90101e4eb2ca30e1a66a76e236e65e56f4a42311cf2faa1"

