# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/portingAids/kdesignerplugin-5.93.0.tar.xz"
SRC_URI[sha256sum] = "f19ab4fc1ed58b89642d8f9f75a5da2f2ef0093c97183f336ffeb7208e628aaf"

