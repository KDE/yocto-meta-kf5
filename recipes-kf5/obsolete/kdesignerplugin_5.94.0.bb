# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/portingAids/kdesignerplugin-5.94.0.tar.xz"
SRC_URI[sha256sum] = "6bd051e47f3a9f301e26b876036b1a36ccf2a2c7e6747f3a96a157c0c3a78a03"

