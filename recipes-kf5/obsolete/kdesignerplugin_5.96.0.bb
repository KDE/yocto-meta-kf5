# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/portingAids/kdesignerplugin-5.96.0.tar.xz"
SRC_URI[sha256sum] = "09e6017565a747c039bc1b1079f65ef4367474733ff21891a006c4964353ad31"

