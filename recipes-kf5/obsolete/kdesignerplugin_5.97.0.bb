# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/portingAids/kdesignerplugin-5.97.0.tar.xz"
SRC_URI[sha256sum] = "28077f1a1b416c2e19f7b8fae1a96d1bde6e4dd8c90905adbe87bb1f2df3fd20"

