# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/portingAids/kdesignerplugin-5.98.0.tar.xz"
SRC_URI[sha256sum] = "ef186dffa0ab9b77491dc074611cfc9bbf8607ac1f2b027a65bf4c43b792609d"

