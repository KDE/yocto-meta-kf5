# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/portingAids/kdesignerplugin-5.99.0.tar.xz"
SRC_URI[sha256sum] = "aee65abd481e2cb8d900b52b9e1bf6c74f71ff7eaa621f562c6285d06d497d73"

