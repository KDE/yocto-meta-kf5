# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kemoticons-5.102.0.tar.xz"
SRC_URI[sha256sum] = "652776296f180f3ebe486380ed6a9c8136f4ad48665f3553c70ca738fc8b342b"

