# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/portingAids/khtml-${PV}.tar.xz"
SRC_URI[sha256sum] = "59a9e74483218ad4894ca74c4f0d3b72b047fdab2e6b74dc5ebd09827a2725e7"

