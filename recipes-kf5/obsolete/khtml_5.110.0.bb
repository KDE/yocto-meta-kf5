# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/portingAids/khtml-${PV}.tar.xz"
SRC_URI[sha256sum] = "361e86f7d0f565f85033b09b583b79b82a25c848f4a71634b0558c1ae53ea89d"

