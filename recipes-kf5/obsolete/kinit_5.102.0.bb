# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kinit-5.102.0.tar.xz"
SRC_URI[sha256sum] = "acb9f420ef5002cd0253d7d8deb240d63a63b7e393c7e2337dfa52a4a3d5ff0e"

