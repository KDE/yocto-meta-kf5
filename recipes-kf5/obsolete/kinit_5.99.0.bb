# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kinit-5.99.0.tar.xz"
SRC_URI[sha256sum] = "2302add7e43a9a32aa9a3d5a73e52757e0b321efea6b15a565bf9f683dd60177"

