# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/portingAids/kjs-5.101.0.tar.xz"
SRC_URI[sha256sum] = "eefef4a9791fb14d3c3a7655df9cd7fbd7068ece4e889f464569ddb83666dc0b"

