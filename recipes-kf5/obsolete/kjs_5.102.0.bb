# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/portingAids/kjs-5.102.0.tar.xz"
SRC_URI[sha256sum] = "7cb48fedcaf68093cb947e7689248c50497a8bd35ccde53e24d7c9b2e7108593"

