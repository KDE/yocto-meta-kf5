# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/portingAids/kjs-5.103.0.tar.xz"
SRC_URI[sha256sum] = "5a46e153dffb8738f265cb1c127b05b47bd234335bc79705beba55aa68d89407"

