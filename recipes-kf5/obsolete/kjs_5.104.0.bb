# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/portingAids/kjs-5.104.0.tar.xz"
SRC_URI[sha256sum] = "bdd6b3f095fa43a3ce779cf380d621f6d2923cd7f33480d3bd281f756b44eb35"

