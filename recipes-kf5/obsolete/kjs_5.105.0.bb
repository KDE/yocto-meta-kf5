# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/portingAids/kjs-5.105.0.tar.xz"
SRC_URI[sha256sum] = "93f87d367ceb0038c622d6c41a54d8fec04014f2e8a76732174074dec77cd31c"

