# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/portingAids/kjs-5.107.0.tar.xz"
SRC_URI[sha256sum] = "6a36b4e812681088cf1dd3d44f7e37352da3c01f510f8a0c906ee1bcf52a2835"

