# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/portingAids/kjs-${PV}.tar.xz"
SRC_URI[sha256sum] = "a5f4bec85662c1c554cf4e7fff3c6c7d9e0ce57e46b2139f9c8140891688133e"

