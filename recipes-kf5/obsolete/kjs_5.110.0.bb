# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/portingAids/kjs-5.110.0.tar.xz"
SRC_URI[sha256sum] = "256c527e77e00cf6c2531b02e171f1485062e55ea7227890bbb11c8d4f6c9376"

