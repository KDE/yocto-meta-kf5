# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/portingAids/kjs-5.83.0.tar.xz"
SRC_URI[sha256sum] = "a8bc37bd3e9d495e9c56d17fdcc3909971447bbe1654088c3cd546ac6662ccba"

