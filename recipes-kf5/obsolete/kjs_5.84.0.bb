# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/portingAids/kjs-5.84.0.tar.xz"
SRC_URI[sha256sum] = "1e03d0f3eb091fea1e0c4809ec334cf8951576a0e45269e0fcde1e7ccdec2162"

