# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/portingAids/kjs-5.85.0.tar.xz"
SRC_URI[sha256sum] = "8b6bff4bae2206cc92b1b7d4f18641809086bcc7b2d83a2c3961987ed28ed446"

