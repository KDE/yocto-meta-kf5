# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/portingAids/kjs-5.86.0.tar.xz"
SRC_URI[sha256sum] = "e2e13dc5136714f48159b83d568f855dbd49a5e9a1dffe4ca97d2bdf85fa653e"

