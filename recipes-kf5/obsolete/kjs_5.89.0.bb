# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/portingAids/kjs-5.89.0.tar.xz"
SRC_URI[sha256sum] = "302a1b40852fae39e95d635d723925f26dd1fbc045d14de71cbb33423926b37b"

