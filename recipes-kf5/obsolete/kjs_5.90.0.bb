# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/portingAids/kjs-5.90.0.tar.xz"
SRC_URI[sha256sum] = "9bab652cadbc3be62d477ac07a7aa0fae296db2ab042097aea06abfd7b0cadfc"

