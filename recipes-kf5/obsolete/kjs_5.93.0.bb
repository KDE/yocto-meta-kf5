# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/portingAids/kjs-5.93.0.tar.xz"
SRC_URI[sha256sum] = "85aa01de9c2775564c895d3efbcfb8cc68da9a84f511176fef16742cbbf90942"

