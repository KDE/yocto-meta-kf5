# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/portingAids/kjs-5.96.0.tar.xz"
SRC_URI[sha256sum] = "77ef6424f79229ff9b5c59a26c77b66e08c0a2b1cf8271c78aebc3b2af940e4a"

