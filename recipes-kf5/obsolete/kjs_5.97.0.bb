# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/portingAids/kjs-5.97.0.tar.xz"
SRC_URI[sha256sum] = "0e59e1d757819943d76e1df8af3f2cbf586b0104aafa8ee7b8b4ea82987bdcf8"

