# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/portingAids/kjs-5.98.0.tar.xz"
SRC_URI[sha256sum] = "339ec922b07a837f7c7a341ad0d5e63edb94e3838c86009a0dd0e9b08a0a3a0e"

