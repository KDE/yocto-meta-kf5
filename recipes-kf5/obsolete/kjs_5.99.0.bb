# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/portingAids/kjs-5.99.0.tar.xz"
SRC_URI[sha256sum] = "40f11254a4c67d679fbda594bf0c5029bf88d555bdb7d31bf4807a28df085e4b"

