# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/portingAids/kjsembed-5.101.0.tar.xz"
SRC_URI[sha256sum] = "0520a3f31b1a8c946d8cf51725745be44fad92e0f909b335d75d330875308c01"

