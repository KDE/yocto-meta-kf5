# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/portingAids/kjsembed-5.102.0.tar.xz"
SRC_URI[sha256sum] = "ba28f907eb3b69e98caf5877883f81051420e664819714fba2696c6093c92f9d"

