# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/portingAids/kjsembed-5.103.0.tar.xz"
SRC_URI[sha256sum] = "2951379fbb10c8eb1e1e6c31ec8ba476f4821daf9d8a8e5f0663de0066bf842c"

