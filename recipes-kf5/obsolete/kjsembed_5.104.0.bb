# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/portingAids/kjsembed-5.104.0.tar.xz"
SRC_URI[sha256sum] = "b011f853ddc5b2cf3c52a834011f0d59bb66e65bd0427bb9b734a1c728d5b10b"

