# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/portingAids/kjsembed-5.105.0.tar.xz"
SRC_URI[sha256sum] = "8a8af23563345649c19adec044a86ee5f37d64c90444d51058cd1c271d1b23b5"

