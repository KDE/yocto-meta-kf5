# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/portingAids/kjsembed-5.107.0.tar.xz"
SRC_URI[sha256sum] = "726e499a415d9967096c81584478a1114128152ca7a062359e2a2ae0976f31ab"

