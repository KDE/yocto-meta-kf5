# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/portingAids/kjsembed-${PV}.tar.xz"
SRC_URI[sha256sum] = "39ad0b51b57adef1780b256f4d44078d50718eae60e40faf2fb7b6e52dc078dd"

