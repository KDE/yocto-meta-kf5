# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/portingAids/kjsembed-5.110.0.tar.xz"
SRC_URI[sha256sum] = "15bb3f6b4d8ee29bcdc8464437c3af3c6ba98fe3e34b0abeac2abdc41492d5fa"

