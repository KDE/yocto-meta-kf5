require ${PN}.inc
# SRCREV = "v${PV}"
SRCREV = "master"
