# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/portingAids/kjsembed-5.83.0.tar.xz"
SRC_URI[sha256sum] = "3aaf4098636bb33142f8787d7f670e5f44a6e482e3916f022afafa771f8cac29"

