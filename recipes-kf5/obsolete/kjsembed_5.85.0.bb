# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/portingAids/kjsembed-5.85.0.tar.xz"
SRC_URI[sha256sum] = "413236f69e6c04fb3df05fb60847ee8fe51d8fd08d46abea79605e789ecb17c9"

