# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/portingAids/kjsembed-5.86.0.tar.xz"
SRC_URI[sha256sum] = "b734c14e69f1acf4708bbb801f3c3b8981f178b8baae994e9065782089805ae1"

