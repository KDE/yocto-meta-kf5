# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/portingAids/kjsembed-5.88.0.tar.xz"
SRC_URI[sha256sum] = "1700da37c2ef365aec02f6d4dee08173d0746ede911ca5a50b9f51960363af2e"

