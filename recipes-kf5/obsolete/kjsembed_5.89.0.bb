# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/portingAids/kjsembed-5.89.0.tar.xz"
SRC_URI[sha256sum] = "4e871eca5e2d29b15717d9a68bbd43304a3739fb92ea4d9c457d391ae0eb5221"

