# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/portingAids/kjsembed-5.90.0.tar.xz"
SRC_URI[sha256sum] = "c466279c3e293035eb72902ae117c30a980e695a60cd2da79eb0acf0cfd3b979"

