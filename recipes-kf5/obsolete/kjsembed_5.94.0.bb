# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/portingAids/kjsembed-5.94.0.tar.xz"
SRC_URI[sha256sum] = "f3ce37479d0f579feeeebc837074b3d138a37989884149b92f12b107fedef62e"

