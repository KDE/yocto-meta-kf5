# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/portingAids/kjsembed-5.96.0.tar.xz"
SRC_URI[sha256sum] = "000ee3f2965f8f783e0e54f526fc505686b45c833f53d73515fae1b0890510fd"

