# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/portingAids/kjsembed-5.97.0.tar.xz"
SRC_URI[sha256sum] = "bd4f24188691631d4d42d11bd58322afd8780a149f46f3cdf496eabed9ed401f"

