# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/portingAids/kjsembed-5.98.0.tar.xz"
SRC_URI[sha256sum] = "c2a9258d4d50e24d7af3c37185aeddedd2caf30bf85af702fb749c0b41de647d"

