# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/portingAids/kjsembed-5.99.0.tar.xz"
SRC_URI[sha256sum] = "fc89d03bf59732f9436ae88dd20505a49d58a7c7bd46858263cb0462d2262070"

