# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/portingAids/kxmlrpcclient-5.99.0.tar.xz"
SRC_URI[sha256sum] = "bd84e005dc605d6512044ee55d1ce739d0d218a8f37c6691d07a40202f3aaa66"

