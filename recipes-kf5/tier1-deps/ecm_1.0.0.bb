require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "0b6114cb6dbd1c4aa0db294e8e105211e9fd4a51"
PV = "1.0.0"
