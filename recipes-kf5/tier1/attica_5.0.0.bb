require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "aebbe875f20b0c5c4be073917366cf10e00a948b"
PV = "5.0.0"
