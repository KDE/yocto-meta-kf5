# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/attica-5.101.0.tar.xz"
SRC_URI[sha256sum] = "7fcbe3686081bc587cbc6b9cc1fbf8f7cb071d06441edc1bea44c958d119da1c"

