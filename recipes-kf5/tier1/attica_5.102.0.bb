# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/attica-5.102.0.tar.xz"
SRC_URI[sha256sum] = "db872f06d57d5ff4ac7701c9f17e93e73c34340553f2b4db137b0b17091df0f6"

