# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/attica-5.103.0.tar.xz"
SRC_URI[sha256sum] = "3a34fca668cc83c6e3ae8dd0138ccd88302959d56bd72fc80621c447a19e609d"

