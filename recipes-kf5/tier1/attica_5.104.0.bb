# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/attica-5.104.0.tar.xz"
SRC_URI[sha256sum] = "c3491c8040986fc4ef1e798b3024d3d7ceee8c00eeca11b4c5c468ae3081b46f"

