# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/attica-5.105.0.tar.xz"
SRC_URI[sha256sum] = "5f1c4fcd74435f387a2a8cccd1ac7434292f3c65d221b84fab4b44e2373109b9"

