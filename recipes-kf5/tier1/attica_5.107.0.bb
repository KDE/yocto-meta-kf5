# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/attica-5.107.0.tar.xz"
SRC_URI[sha256sum] = "fdcb3cca97c3705eef360e483d25eec887e1d42c43c77c815ad42a0972ee13f8"

