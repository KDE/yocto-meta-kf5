# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/attica-${PV}.tar.xz"
SRC_URI[sha256sum] = "7329ec6dacfd814c0ea6a63d9b08f48963c2fd21d7d0b7d13cbabccbeb7400f1"

