# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/attica-5.110.0.tar.xz"
SRC_URI[sha256sum] = "a6f5abb1834afa0bcc12e3315489377a492b18a26fbac0d91c695f3b32f0e7d2"

