# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/attica-5.83.0.tar.xz"
SRC_URI[sha256sum] = "46c847699d9f5c16683f30d589522de91d296bf257d4afdc2faefc406306abee"

