# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/attica-5.86.0.tar.xz"
SRC_URI[sha256sum] = "992ffe3743588b81a63dcb3886d406f63800423bd442e3b99058bfc80f0e467f"

