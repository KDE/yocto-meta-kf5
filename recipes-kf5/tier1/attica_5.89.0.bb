# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/attica-5.89.0.tar.xz"
SRC_URI[sha256sum] = "e9be19c0e4ddbd3e142e9d86493ac4edc8ad00b4866d2601343dd0ccb754020f"

