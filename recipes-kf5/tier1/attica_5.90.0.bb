# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/attica-5.90.0.tar.xz"
SRC_URI[sha256sum] = "9372f1f1733c33bc36c3180b821bb1a12d1808735de86bce742aae043d3e437f"

