# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/attica-5.93.0.tar.xz"
SRC_URI[sha256sum] = "81c18009911beb07d1868de78dd7fc1c4b1e8312bd95d916f4d4a80a800592e1"

