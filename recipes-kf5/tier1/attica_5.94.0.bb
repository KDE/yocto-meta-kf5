# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/attica-5.94.0.tar.xz"
SRC_URI[sha256sum] = "f6293699da5794812080ba2d41b4ea05e830532678af324d8e852f508f2def65"

