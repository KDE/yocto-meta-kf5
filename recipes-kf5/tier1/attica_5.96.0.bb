# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/attica-5.96.0.tar.xz"
SRC_URI[sha256sum] = "e7fecc846d4d383d7b719aa9de22b95a31ab1c98375f0d784bb790e696168ff6"

