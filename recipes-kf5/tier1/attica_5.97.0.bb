# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/attica-5.97.0.tar.xz"
SRC_URI[sha256sum] = "c5f82aac64fc59376eaca14190e7a31d3697b41f9468375f43ef0890573b3832"

