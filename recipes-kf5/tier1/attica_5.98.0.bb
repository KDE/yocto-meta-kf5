# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/attica-5.98.0.tar.xz"
SRC_URI[sha256sum] = "d74e356e264238b2c71012ebc55a5090183c6bf7b0096ba51838a82805373c70"

