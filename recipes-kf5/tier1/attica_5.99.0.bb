# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/attica-5.99.0.tar.xz"
SRC_URI[sha256sum] = "175ad3b299713b9c1cfcb6d5fe8ce4f86d3065fba4ab7728090d998d6c6363b1"

