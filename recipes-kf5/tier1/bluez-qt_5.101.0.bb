# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/bluez-qt-5.101.0.tar.xz"
SRC_URI[sha256sum] = "15de3a3c64367d753ef165619b9d3a452e86ca123e6a8a1fe6a4067b355ae203"

