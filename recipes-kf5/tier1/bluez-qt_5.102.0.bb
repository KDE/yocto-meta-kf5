# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/bluez-qt-5.102.0.tar.xz"
SRC_URI[sha256sum] = "c3f90b1642c461f0cb261b31db5eacf7d30cc37442b828f19f1347ab29b44300"

