# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/bluez-qt-5.103.0.tar.xz"
SRC_URI[sha256sum] = "ff431505377a5e3598de4beab414133b32f4812de476bb5fd82e1aa22c1bd8f0"

