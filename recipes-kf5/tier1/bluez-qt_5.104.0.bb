# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/bluez-qt-5.104.0.tar.xz"
SRC_URI[sha256sum] = "701b7e675ab5b4808ece331027c3c53bd2b765f0f39d7a4652a32c195c88e9f5"

