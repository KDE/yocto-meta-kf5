# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/bluez-qt-5.105.0.tar.xz"
SRC_URI[sha256sum] = "c6ed49324afd7a5c7c1668bfdf2b2accec748fdd867d8c893881b59ff413d583"

