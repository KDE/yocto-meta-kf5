# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/bluez-qt-5.107.0.tar.xz"
SRC_URI[sha256sum] = "2f2ab08681e9014d7884fc345b72a91611d98e9b453df95c9be627aaf7b9ce71"

