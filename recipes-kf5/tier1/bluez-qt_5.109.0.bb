# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/bluez-qt-${PV}.tar.xz"
SRC_URI[sha256sum] = "89c2369152dfc98cd954615034e02c09d0b27ef83c55c184f70b369071a8749c"

