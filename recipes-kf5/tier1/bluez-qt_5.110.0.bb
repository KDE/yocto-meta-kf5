# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/bluez-qt-5.110.0.tar.xz"
SRC_URI[sha256sum] = "9f819ab749364f976da25c4d01f7bf4c1da615e6a7fd468c62b74d0a624179f7"

