# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/bluez-qt-5.83.0.tar.xz"
SRC_URI[sha256sum] = "1bb9daacfdfca83a8963c5269cb028c42a761eb2f9ae2cac36c9475b06536d3b"

