# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/bluez-qt-5.84.0.tar.xz"
SRC_URI[sha256sum] = "909ab90b3a3868314d37c2223458b047011a6a4baae0f0d2183bc9b380fce65d"

