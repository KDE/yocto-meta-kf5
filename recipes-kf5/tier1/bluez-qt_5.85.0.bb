# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/bluez-qt-5.85.0.tar.xz"
SRC_URI[sha256sum] = "a85b2a5601c50f6b3ade1396624d008ad405de4bda81f77ccaddd55837d700a2"

