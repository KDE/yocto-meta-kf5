# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/bluez-qt-5.86.0.tar.xz"
SRC_URI[sha256sum] = "d40edef8b29014fb18e8b2e81514c76fe46ebbbee109397611b18d58c52061fe"

