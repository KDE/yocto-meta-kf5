# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/bluez-qt-5.88.0.tar.xz"
SRC_URI[sha256sum] = "3f8c0dbc2a8264e77a218a77893d9584b957dd7905de77e6eda0f9fb112ae509"

