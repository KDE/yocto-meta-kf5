# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/bluez-qt-5.89.0.tar.xz"
SRC_URI[sha256sum] = "854b90b9315afcf63067668d5fa4e9a03e33ba31ad1827a308f177b8b7fc8c03"

