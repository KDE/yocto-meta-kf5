# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/bluez-qt-5.90.0.tar.xz"
SRC_URI[sha256sum] = "e38770ada90cb66fcc891c89a020bc4d510a1dbd4025d257a8d895979b2dd114"

