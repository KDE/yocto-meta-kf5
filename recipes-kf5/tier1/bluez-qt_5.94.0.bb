# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/bluez-qt-5.94.0.tar.xz"
SRC_URI[sha256sum] = "7e776feb095e727abea0fec4b3ae3c81d704a0527b8ff3257d799feee2cc0632"

