# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/bluez-qt-5.96.0.tar.xz"
SRC_URI[sha256sum] = "8272bfb469559e16758a1743a508c488168e2f47770fb25d2bd72abb12ae8779"

