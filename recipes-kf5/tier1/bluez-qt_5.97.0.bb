# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/bluez-qt-5.97.0.tar.xz"
SRC_URI[sha256sum] = "033a9fd5f3a8bcf54649bae79dbad036f8c4cf74683809c1c908807270e6ea99"

