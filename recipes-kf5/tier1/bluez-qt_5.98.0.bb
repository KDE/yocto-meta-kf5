# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/bluez-qt-5.98.0.tar.xz"
SRC_URI[sha256sum] = "4fdc9835eb24dea9ce9959734a69332c66a84a3f3a97682f0b22d9a923165340"

