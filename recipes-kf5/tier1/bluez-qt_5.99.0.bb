# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/bluez-qt-5.99.0.tar.xz"
SRC_URI[sha256sum] = "e7c91bb168a187f87c68fe6918e676d8ee7c933de1237db06b45761f263dcf85"

