# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/breeze-icons-5.101.0.tar.xz"
SRC_URI[sha256sum] = "f9745944a04860d002f3b95df21fe560b6fbd7d515b8a06ec60da63644a018ef"

