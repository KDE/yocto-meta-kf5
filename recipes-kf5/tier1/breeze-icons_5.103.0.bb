# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/breeze-icons-5.103.0.tar.xz"
SRC_URI[sha256sum] = "7925d70ef2078316f69b9d26e7b1536844fb1d3c045fc78a2464c54871415abd"

