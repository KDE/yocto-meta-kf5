# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/breeze-icons-5.105.0.tar.xz"
SRC_URI[sha256sum] = "2328b09ca0a9d4ca1efb13132995f837d3d30452b50646cbf5d91f6584d8a679"

