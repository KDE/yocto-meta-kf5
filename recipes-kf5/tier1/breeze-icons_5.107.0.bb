# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/breeze-icons-5.107.0.tar.xz"
SRC_URI[sha256sum] = "67b25fefb3ba0864e6c1293397bda16c31d5a04aecc7332deaaf004d86bf103a"

