# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/breeze-icons-${PV}.tar.xz"
SRC_URI[sha256sum] = "e07a0be85f4fe67576204339be9ac9c6809618b16963fb147d59a325380c54b2"

