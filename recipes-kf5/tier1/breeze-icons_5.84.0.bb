# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/breeze-icons-5.84.0.tar.xz"
SRC_URI[sha256sum] = "049a26594de966a215ea4546bbf76a2395def31a637eb26820258d7c0962408c"

