# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/breeze-icons-5.85.0.tar.xz"
SRC_URI[sha256sum] = "4407aed678f85ab600b63337553ee9cd5f967bbffd383c351add1c0746ab273d"

