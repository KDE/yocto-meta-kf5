# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/breeze-icons-5.96.0.tar.xz"
SRC_URI[sha256sum] = "43a02e6111c87686e24ba570078f31e77af105a5e2eea490f6d375e3f11047c6"

