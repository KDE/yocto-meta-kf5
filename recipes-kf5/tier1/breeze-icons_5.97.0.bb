# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/breeze-icons-5.97.0.tar.xz"
SRC_URI[sha256sum] = "6eae442282779802c348e91080132d52b0229288cc8793b2aaa6f906e39171a3"

