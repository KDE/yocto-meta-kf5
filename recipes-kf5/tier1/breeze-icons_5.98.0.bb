# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/breeze-icons-5.98.0.tar.xz"
SRC_URI[sha256sum] = "57ea7d0fe96a520cb63828d0a6f44de92673a81ede4a7f25d8dd6ac760dd7f28"

