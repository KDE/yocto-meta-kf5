# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/breeze-icons-5.99.0.tar.xz"
SRC_URI[sha256sum] = "480f699c04382c91997ff954e645f134ee513817bde2799675fa484956cd3cfd"

