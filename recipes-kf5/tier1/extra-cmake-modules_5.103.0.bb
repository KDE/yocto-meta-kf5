# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/extra-cmake-modules-5.103.0.tar.xz"
SRC_URI[sha256sum] = "92ca2e55cb38956fbdeaf254231f074647173ccfd12dc9664989c6fa9e9c4346"

