# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/extra-cmake-modules-5.104.0.tar.xz"
SRC_URI[sha256sum] = "e49eb21fdb66634b84cccbf6ba65eae3f8e0eee0dc72d50f627280f49df585d9"

