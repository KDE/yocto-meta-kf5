# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/extra-cmake-modules-5.107.0.tar.xz"
SRC_URI[sha256sum] = "3969aad56d1e6a5901e926aaf7a73510d98c4b363564ed3f1222d4135da633ed"

