# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/extra-cmake-modules-${PV}.tar.xz"
SRC_URI[sha256sum] = "1526b557cf9718e4d3bf31ff241578178d1ee60bdfb863110c97d43d478b7fb7"

