# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/extra-cmake-modules-5.110.0.tar.xz"
SRC_URI[sha256sum] = "7746f5db3e230ee2485e603580cc4c7cec636c3258c0a909766fb281913f6438"

