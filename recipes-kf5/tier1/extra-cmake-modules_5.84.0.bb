# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/extra-cmake-modules-5.84.0.tar.xz"
SRC_URI[sha256sum] = "bb085ef2e177c182ff46988516b6b31849d1497beb2ff5301165ad2ba12a1c41"

