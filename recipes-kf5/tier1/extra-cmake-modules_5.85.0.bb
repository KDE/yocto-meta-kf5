# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/extra-cmake-modules-5.85.0.tar.xz"
SRC_URI[sha256sum] = "7a4209c3b113dc50250920186a2d30b71870e11ebb92a700a611b423ce6b6634"

