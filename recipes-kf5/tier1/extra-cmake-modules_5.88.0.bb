# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/extra-cmake-modules-5.88.0.tar.xz"
SRC_URI[sha256sum] = "33bd83908daa531654455b77fc121b598f757aadf8ba01dbacfda8b8fb050319"

