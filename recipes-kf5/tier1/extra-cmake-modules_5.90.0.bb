# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/extra-cmake-modules-5.90.0.tar.xz"
SRC_URI[sha256sum] = "f3007c3ceca56249292cf340a38518589a55a4afcf27e166ab63c5ac8ffabcb0"

