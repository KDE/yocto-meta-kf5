# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/extra-cmake-modules-5.93.0.tar.xz"
SRC_URI[sha256sum] = "093dea7b11647bc5f74e6971d47ef15b5c410cba2b4620acae00f008d5480b21"

