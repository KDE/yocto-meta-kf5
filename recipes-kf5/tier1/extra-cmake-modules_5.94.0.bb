# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/extra-cmake-modules-5.94.0.tar.xz"
SRC_URI[sha256sum] = "23548a8ce2b998cfa675fc00112bf93914ee25194f0bfdf832d283c8d678d279"

