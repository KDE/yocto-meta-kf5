# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/extra-cmake-modules-5.98.0.tar.xz"
SRC_URI[sha256sum] = "3c198f9e4840a0fbfb8d322f2f2711daae20e5bbfd68e998ba9078bc51aac918"

