# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/extra-cmake-modules-5.99.0.tar.xz"
SRC_URI[sha256sum] = "01818aa606628db57129f6e22dbae3532464220802d085c6e0689d032e87807e"

