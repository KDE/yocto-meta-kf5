# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/karchive-5.102.0.tar.xz"
SRC_URI[sha256sum] = "40ecd08803b9951777eba0307aa98d879af78b0747d4f810ae8a63e76fcfd84a"

