# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/karchive-5.105.0.tar.xz"
SRC_URI[sha256sum] = "77ef95cf4c525fe74261c7dd817564a35e726e5c1c4d1e1479fdfec187da9749"

