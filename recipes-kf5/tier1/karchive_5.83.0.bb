# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/karchive-5.83.0.tar.xz"
SRC_URI[sha256sum] = "5ca9953951a778f759c04cfacb8bbc1e103a9cafabafceceb3d25568b3a2e379"

