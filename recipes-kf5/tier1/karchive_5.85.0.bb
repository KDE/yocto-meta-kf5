# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/karchive-5.85.0.tar.xz"
SRC_URI[sha256sum] = "8c196e9195485622c7e5f4523584e1e7551827a0bfbe477d08d34b7847ab6b2f"

