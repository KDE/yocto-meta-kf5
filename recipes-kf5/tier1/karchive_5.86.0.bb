# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/karchive-5.86.0.tar.xz"
SRC_URI[sha256sum] = "13bfb0a07171bab829c3cb6760d60817608ba95802a4dfe0327cb2afb4616e9d"

