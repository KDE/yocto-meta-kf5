# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/karchive-5.93.0.tar.xz"
SRC_URI[sha256sum] = "61e326a840860270b7f8b9e8966462085b4f309be5c3a84c3b265eb95694c7fb"

