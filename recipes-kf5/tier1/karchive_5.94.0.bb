# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/karchive-5.94.0.tar.xz"
SRC_URI[sha256sum] = "55cd87a5437a649c168efbce4af132b992aa67dd9a3a8ced7cff0144f155e1e4"

