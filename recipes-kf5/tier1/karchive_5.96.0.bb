# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/karchive-5.96.0.tar.xz"
SRC_URI[sha256sum] = "c5f5dec93a296a411cf2e44f4b626da316699f04ec574e634310f622040e2aaf"

