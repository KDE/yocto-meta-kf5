# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/karchive-5.98.0.tar.xz"
SRC_URI[sha256sum] = "02c7c60c35c9ad0611d70be3186f017a716c201a51de8bc137e5191e833cf2c6"

