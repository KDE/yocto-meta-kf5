# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/karchive-5.99.0.tar.xz"
SRC_URI[sha256sum] = "571957caf8304344ef3d5b47092be96563e1526d4a1d70abf04ebcc38dd495fc"

