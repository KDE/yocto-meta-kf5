# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kcalendarcore-5.101.0.tar.xz"
SRC_URI[sha256sum] = "3acb875423dc155d92408a9772ae2ad85f0c69f1033ea777a2326559f11e109c"

