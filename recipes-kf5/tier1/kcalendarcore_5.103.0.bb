# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kcalendarcore-5.103.0.tar.xz"
SRC_URI[sha256sum] = "77c13bb1d57ec6f30595ec2b1c77e3c68e7e60c8b8ac630d5cf4d8c8e3614edd"

