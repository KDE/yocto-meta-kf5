# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kcalendarcore-5.105.0.tar.xz"
SRC_URI[sha256sum] = "fed213d9b3243721cfdd8deca2036d478d3211268c6f8e26abfa37e2ef28abdc"

