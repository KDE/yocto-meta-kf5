# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kcalendarcore-5.107.0.tar.xz"
SRC_URI[sha256sum] = "54d742bad1ccc5c4b03d0985c1b4b202714af3b0c92efe6631c4c671e8b25c47"

