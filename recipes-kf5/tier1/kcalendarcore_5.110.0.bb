# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kcalendarcore-5.110.0.tar.xz"
SRC_URI[sha256sum] = "a250fb1ba0091352d8850a06ebb2032097a952970b1aafd8261ec745c90beba7"

