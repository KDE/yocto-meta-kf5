# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kcalendarcore-5.83.0.tar.xz"
SRC_URI[sha256sum] = "ebcbe910d25c27d029fe6669e53190aebbf6b1f2a20c4ee5e45adb42c992af1f"

