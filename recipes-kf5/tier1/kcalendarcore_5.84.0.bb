# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kcalendarcore-5.84.0.tar.xz"
SRC_URI[sha256sum] = "8b116cf5dff328597b74a550a938ce3e3a64fcbf7022c692b07691a9dbf35a19"

