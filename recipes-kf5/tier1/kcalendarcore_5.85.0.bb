# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kcalendarcore-5.85.0.tar.xz"
SRC_URI[sha256sum] = "58fb1df9adac73fe8fd73f8a74ffe2c9ba8e7a6d196046aba56497471a77d912"

