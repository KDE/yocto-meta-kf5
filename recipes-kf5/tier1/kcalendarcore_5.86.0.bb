# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kcalendarcore-5.86.0.tar.xz"
SRC_URI[sha256sum] = "9639ed7a650e3471d58b9fdb864975e365350c3198d89dcb101ea312d40cb2b4"

