# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kcalendarcore-5.88.0.tar.xz"
SRC_URI[sha256sum] = "5e13d34179f5e315cf5301286340e52b3dc78d4f48927b7f2f0bbf453f03cc43"

