# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kcalendarcore-5.89.0.tar.xz"
SRC_URI[sha256sum] = "57ddb7d771a01bc7cec4739000b9be0583d3cfacb18fa0669a7850595a21c0f7"

