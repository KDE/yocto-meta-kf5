# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kcalendarcore-5.90.0.tar.xz"
SRC_URI[sha256sum] = "1ca94b91bbbc377be462bdf005392e187a6e5adb3ac2bc2fc7396da9bdd06d61"

