# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kcalendarcore-5.93.0.tar.xz"
SRC_URI[sha256sum] = "1609bc141739fce0abed59a353a0e356f4fa7a1b3659d3bc77737010875c1d3f"

