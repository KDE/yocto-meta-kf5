# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kcalendarcore-5.97.0.tar.xz"
SRC_URI[sha256sum] = "d8a7ae053f0620e51e36b04a29240425f293077bad5a8298ed9c09ce97f4e690"

