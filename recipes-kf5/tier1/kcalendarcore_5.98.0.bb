# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kcalendarcore-5.98.0.tar.xz"
SRC_URI[sha256sum] = "d3abd98486515b91345186cc05f18531247645a428867f804d8d7ea9afa66c9a"

