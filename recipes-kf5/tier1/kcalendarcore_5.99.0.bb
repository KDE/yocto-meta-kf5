# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kcalendarcore-5.99.0.tar.xz"
SRC_URI[sha256sum] = "1951c46acbaa0475190bfd35f00398dbe9031e25ebe8d8f7508d60f0a77cec87"

