# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kcodecs-5.101.0.tar.xz"
SRC_URI[sha256sum] = "9ebc28f2101cfafe544d6593f7d23b0438df2a77f8dc7d1f41afc1066846523a"

