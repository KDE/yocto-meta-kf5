# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kcodecs-5.102.0.tar.xz"
SRC_URI[sha256sum] = "08f57c0cea6b9a0eca2c1d6de8503047b3c32c6a64f5752c8ab2892517cd6396"

