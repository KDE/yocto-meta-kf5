# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kcodecs-5.103.0.tar.xz"
SRC_URI[sha256sum] = "5e14cae3ec139eec76439ab38b3e379be955f35b8dd2d480e66510c709e26f39"

