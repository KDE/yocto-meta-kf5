# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kcodecs-5.104.0.tar.xz"
SRC_URI[sha256sum] = "7ec909f6865eba87a99b046a9aeaa6a83c01308ad1dda87be3f69e91a7909d6b"

