# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kcodecs-5.105.0.tar.xz"
SRC_URI[sha256sum] = "c2e3c65d4fbac9fa3d47aa382764066ff875de0e3d8ff2bb87cf567f4e50e572"

