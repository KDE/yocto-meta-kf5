# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kcodecs-5.107.0.tar.xz"
SRC_URI[sha256sum] = "07b08563c0a4b29bbf08ea7a36c410d64936ab5e27cc772b8ca4f27a75a11221"

