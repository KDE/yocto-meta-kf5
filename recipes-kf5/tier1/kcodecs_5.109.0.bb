# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kcodecs-${PV}.tar.xz"
SRC_URI[sha256sum] = "9648fe05222c0755441a2091e4f97fd7b65649bcbaa2fb8c120e90d9c8934ca5"

