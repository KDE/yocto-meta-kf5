# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kcodecs-5.110.0.tar.xz"
SRC_URI[sha256sum] = "3b6c8f315fb23479c15fc369bb5f4e10c34a607a5bb6f4ba16c7b6f026c225c4"

