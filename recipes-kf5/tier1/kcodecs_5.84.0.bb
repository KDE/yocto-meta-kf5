# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kcodecs-5.84.0.tar.xz"
SRC_URI[sha256sum] = "233f7123b045562c8ea7862eb40c27e551f6b463f9ed4fce4583433601f9523a"

