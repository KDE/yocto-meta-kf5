# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kcodecs-5.85.0.tar.xz"
SRC_URI[sha256sum] = "65060af4bd3775aca56066f779ee4eeb34e05bf372023be2974302794e88f7fd"

