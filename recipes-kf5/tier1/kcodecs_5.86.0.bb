# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kcodecs-5.86.0.tar.xz"
SRC_URI[sha256sum] = "2096cb5799732b3a953bacb6fcb0319b43f8a933d78691b9df28b50166b42b33"

