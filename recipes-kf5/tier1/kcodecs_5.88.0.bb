# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kcodecs-5.88.0.tar.xz"
SRC_URI[sha256sum] = "d16b6c87b2daf27f1845d61307666b0f451658322ac2ed469966d7560af917e9"

