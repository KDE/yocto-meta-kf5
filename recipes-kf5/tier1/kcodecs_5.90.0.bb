# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kcodecs-5.90.0.tar.xz"
SRC_URI[sha256sum] = "d0c604564745a1a50b01d61aa52282cad08dfdb37aecca30d5f80ea325f4984f"

