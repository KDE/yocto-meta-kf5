# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kcodecs-5.93.0.tar.xz"
SRC_URI[sha256sum] = "0efc5c8baab3142f8a0ab9369b255061772a57a80fb616b7305bf98235b2288b"

