# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kcodecs-5.94.0.tar.xz"
SRC_URI[sha256sum] = "bcc0e9fb1c1d259f05a326de160639a46c4bb6e0cce6fbc8244c39f251b8e7f9"

