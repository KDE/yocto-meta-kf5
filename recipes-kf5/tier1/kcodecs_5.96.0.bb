# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kcodecs-5.96.0.tar.xz"
SRC_URI[sha256sum] = "7147e4ae29082f5403e21cb7940b3546c094192095f22ed6c5c3fdda25374614"

