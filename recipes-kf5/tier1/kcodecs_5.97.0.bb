# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kcodecs-5.97.0.tar.xz"
SRC_URI[sha256sum] = "63e6e517a80395faea285968fd13f5e477a7437cb28c7028e9e678fc068d2670"

