# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kcodecs-5.98.0.tar.xz"
SRC_URI[sha256sum] = "9fc9403290f0f933b3f2e3bc182d008dce2048c481544ff7b9bd889cf4c92058"

