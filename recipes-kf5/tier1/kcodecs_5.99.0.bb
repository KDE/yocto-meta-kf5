# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kcodecs-5.99.0.tar.xz"
SRC_URI[sha256sum] = "62cd8011339db338c84dd06b009b8c26632e3c559177782e2b7b12c799862076"

