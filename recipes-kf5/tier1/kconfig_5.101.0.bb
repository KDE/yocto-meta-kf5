# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kconfig-5.101.0.tar.xz"
SRC_URI[sha256sum] = "ca747e485756e6d65e4eed85d1187c80b7facc958f379a68fbe862f068cb5383"

