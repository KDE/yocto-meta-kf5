# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kconfig-5.102.0.tar.xz"
SRC_URI[sha256sum] = "f68e6705d38ed7e0d31b62979564149912db8d3959b64eddf7424cabdc13ac33"

