# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kconfig-5.104.0.tar.xz"
SRC_URI[sha256sum] = "b8e7a6b7b0e78e3eb01755a965d893bd95c231befeff10479243e5a182ec2938"

