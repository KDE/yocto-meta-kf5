# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kconfig-5.105.0.tar.xz"
SRC_URI[sha256sum] = "3e95f516a1e939067550a243a46cc33961d1c9b116330913176e6ea55760e152"

