# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kconfig-5.107.0.tar.xz"
SRC_URI[sha256sum] = "9697d4bca5255e62df99f7e80b4d0f22d532317b4bff3d67e81c4f7641ee5b13"

