# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kconfig-5.110.0.tar.xz"
SRC_URI[sha256sum] = "ad2b88bdbb788ed0df5cbdc95ebd24c197d0fee35c08f78acf3e2398016c31c5"

