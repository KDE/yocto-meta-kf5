# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kconfig-5.83.0.tar.xz"
SRC_URI[sha256sum] = "7c84a05609a22a2bd7185fc46e73a0d39604340574d5e85e24b170e84f84eee8"

