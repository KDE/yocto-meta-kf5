# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kconfig-5.84.0.tar.xz"
SRC_URI[sha256sum] = "aa4a30c095ab365fa121cda18e0304bc9a0e774cf4b07a420ed534d221795073"

