# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kconfig-5.85.0.tar.xz"
SRC_URI[sha256sum] = "bad5482894d3dcf8bf213217c0a8bb7baba3803a737befcecaf83cda23dab962"

