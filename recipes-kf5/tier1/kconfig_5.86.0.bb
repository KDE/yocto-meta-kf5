# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kconfig-5.86.0.tar.xz"
SRC_URI[sha256sum] = "c177b3d6fb2761133042a1adcbc0eebe52719730333e2089424a5edd21e60417"

