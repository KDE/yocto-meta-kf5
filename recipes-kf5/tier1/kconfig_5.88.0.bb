# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kconfig-5.88.0.tar.xz"
SRC_URI[sha256sum] = "3414e40306c294e28a376e73b5e871ddf2cfc06b751396244dcc585aecd402ac"

