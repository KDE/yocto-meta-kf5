# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kconfig-5.89.0.tar.xz"
SRC_URI[sha256sum] = "8eb17cedac15cef8f1b2d9ceaa20b74ccfdd66b935f1d223b17ea1e631a0b147"

