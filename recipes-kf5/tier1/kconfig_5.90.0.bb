# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kconfig-5.90.0.tar.xz"
SRC_URI[sha256sum] = "369bf21d3d7a894575728b0061875e4122de13935c0740733e0bc2df9b1f1a7b"

