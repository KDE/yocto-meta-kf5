# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kconfig-5.93.0.tar.xz"
SRC_URI[sha256sum] = "71857c20d4829017c22dd6d46ae5a642c86344960e21bc1520458fb76d02c06e"

