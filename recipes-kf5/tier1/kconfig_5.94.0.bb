# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kconfig-5.94.0.tar.xz"
SRC_URI[sha256sum] = "8e6d9104f070d94f083be000ea116acae3499b0dd110fa4c9c55f51ea91cb3d7"

