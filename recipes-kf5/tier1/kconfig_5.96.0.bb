# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kconfig-5.96.0.tar.xz"
SRC_URI[sha256sum] = "1ffa71145390ea34356cd8fe676794cb9b5bc3db9e1bb1b01be8a42e6aef48f5"

