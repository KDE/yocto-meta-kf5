# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kconfig-5.97.0.tar.xz"
SRC_URI[sha256sum] = "90fe770c7f9c3a933b4e1f3576cf70c15d1db70b86bc9cfa9e4ad289e053f62d"

