# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kconfig-5.98.0.tar.xz"
SRC_URI[sha256sum] = "5ece35a8309a950c240f4dc9f8b3e2f7e0f377fdf654df90c10299ecde5ba296"

