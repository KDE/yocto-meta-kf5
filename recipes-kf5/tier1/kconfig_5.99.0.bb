# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kconfig-5.99.0.tar.xz"
SRC_URI[sha256sum] = "5dc7c3d22ff64579a234a9e7de22f2859158595cc4956db13608841ea0d258a6"

