require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "3bf93e981bd0f25dc06fb7e373f8b2b3b7e19a5f"
PV = "5.0.0"
