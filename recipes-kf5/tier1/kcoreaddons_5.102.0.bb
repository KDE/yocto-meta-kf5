# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kcoreaddons-5.102.0.tar.xz"
SRC_URI[sha256sum] = "82e3f91993602e0b596899d9b43ff78c88566fd1209ec2f78665fb45cda20948"

