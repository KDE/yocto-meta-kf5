# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kcoreaddons-5.103.0.tar.xz"
SRC_URI[sha256sum] = "beb99d0274c2bffd8e6aa87199438393222a0317e2e1118d510b5b6abf772f6a"

