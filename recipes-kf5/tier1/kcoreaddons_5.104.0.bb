# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kcoreaddons-5.104.0.tar.xz"
SRC_URI[sha256sum] = "ed760d4a7fed6c03480dcc3cfe621a49ac5ca9853c846080afe393f7ce794e40"

