# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kcoreaddons-5.105.0.tar.xz"
SRC_URI[sha256sum] = "915cd3ac5bb3963fe79a643d70f109a9aa198f97e6a2b5c72f09cd955238daa2"

