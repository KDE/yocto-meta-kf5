# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kcoreaddons-5.107.0.tar.xz"
SRC_URI[sha256sum] = "64baee484852ab2798aba18cc4780a1caafb688a5e0a0524de3bc7eb2a1eaf84"

