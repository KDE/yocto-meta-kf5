# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kcoreaddons-${PV}.tar.xz"
SRC_URI[sha256sum] = "ff647fc1d4dd62370f261854af0870f2a1c7ba7abe7e276e5a4c42d923f15300"

