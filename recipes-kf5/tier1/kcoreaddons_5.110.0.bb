# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kcoreaddons-5.110.0.tar.xz"
SRC_URI[sha256sum] = "6e8de80ccc003606af7f89c354719d012bdab5dde156c5505df32861e0158d75"

