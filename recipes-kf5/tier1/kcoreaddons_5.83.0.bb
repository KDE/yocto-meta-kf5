# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kcoreaddons-5.83.0.tar.xz"
SRC_URI[sha256sum] = "723c99b63c159f6c70ef4a56acbab8afdc54a9fa3269ff7a21ed2467179e8a57"

