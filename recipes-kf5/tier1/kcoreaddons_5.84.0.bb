# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kcoreaddons-5.84.0.tar.xz"
SRC_URI[sha256sum] = "754d3ca6efe5796f671d65a4529d2b3775187c8e26e78275b40a4b012c131fb0"

