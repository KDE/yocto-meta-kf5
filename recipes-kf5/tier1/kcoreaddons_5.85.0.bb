# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kcoreaddons-5.85.0.tar.xz"
SRC_URI[sha256sum] = "90af5743a9e199e213e812313adf08c9034d1d79936565f22075ccb3f7445414"

