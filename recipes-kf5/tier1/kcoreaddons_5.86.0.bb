# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kcoreaddons-5.86.0.tar.xz"
SRC_URI[sha256sum] = "c63f3ebea0cf6c53334ad5a28ed2d278700a6d0e01a841ee8df5fa8c27729cd9"

