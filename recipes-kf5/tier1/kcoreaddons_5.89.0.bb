# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kcoreaddons-5.89.0.tar.xz"
SRC_URI[sha256sum] = "e1d085786b6247e71f918b6d90ab8a4c09d37816ba296981858e8a8f3e3f426b"

