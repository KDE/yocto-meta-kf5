# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kcoreaddons-5.90.0.tar.xz"
SRC_URI[sha256sum] = "6e168f1d719e4c388de324960d14b99963d42c74a21986f027c9b7093281a40a"

