# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kcoreaddons-5.93.0.tar.xz"
SRC_URI[sha256sum] = "920a278af97dea3add06770a6f3604744c20d667973cb71cf477145785dbf043"

