# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kcoreaddons-5.96.0.tar.xz"
SRC_URI[sha256sum] = "d21a4c9aa79caa87f543c46ef71a2e290a768edd861e901ea50a452d80fcb5d8"

