# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kcoreaddons-5.97.0.tar.xz"
SRC_URI[sha256sum] = "09403513873e4fc3d9d2d13fb486d9cce0bc6bd5fde0b1c7b2481e0a404202aa"

