# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kcoreaddons-5.98.0.tar.xz"
SRC_URI[sha256sum] = "a2e42853ab12e7da4799287e62cfe4ed7846cc1ea6abfadac3811fae71f71553"

