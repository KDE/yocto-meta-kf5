# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kcoreaddons-5.99.0.tar.xz"
SRC_URI[sha256sum] = "5a76a33d3971b1d748db13faf76ab7a863310dccb374ebff69f24ef9c7f4131b"

