require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "25a4c2d62f749cd96a3885a1e0f67b0facc840c6"
PV = "5.0.0"
