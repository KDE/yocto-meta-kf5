# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kdbusaddons-5.102.0.tar.xz"
SRC_URI[sha256sum] = "f1bbee6eed45614fd373bf735a5752d718c8dc590f101dae2b3dae348e9d1ad3"

