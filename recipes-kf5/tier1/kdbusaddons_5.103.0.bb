# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kdbusaddons-5.103.0.tar.xz"
SRC_URI[sha256sum] = "c675b706ab2b49c4f7de805fdf9e2a5e00419bd856df7af0fd6a2a6628eba4e3"

