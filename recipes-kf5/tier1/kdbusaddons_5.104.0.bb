# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kdbusaddons-5.104.0.tar.xz"
SRC_URI[sha256sum] = "4c6add0481c407bc3768729e27e8644feba748c333872e62aaa3260338fd56b4"

