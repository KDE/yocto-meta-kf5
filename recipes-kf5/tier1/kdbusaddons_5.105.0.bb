# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kdbusaddons-5.105.0.tar.xz"
SRC_URI[sha256sum] = "5a257b294d85ef3485dcf05a23d94769bf0d70a8689508e24cb209a8c25ffedd"

