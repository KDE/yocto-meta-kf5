# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kdbusaddons-5.107.0.tar.xz"
SRC_URI[sha256sum] = "4e96e3c31eb254b6a48aad20b86c8fa4806a45f6c0644b672413a3ca88eb09b8"

