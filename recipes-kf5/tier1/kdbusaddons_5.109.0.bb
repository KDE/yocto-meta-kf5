# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kdbusaddons-${PV}.tar.xz"
SRC_URI[sha256sum] = "251876bc1a0006741a32406bf52d4f0034f69c4dec9842a47353f5221965f035"

