# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kdbusaddons-5.110.0.tar.xz"
SRC_URI[sha256sum] = "10ad0ec26b1a7076110a0fd431e5a4a26dbcf62da070888e93b9b3028f999f46"

