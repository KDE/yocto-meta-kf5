# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kdbusaddons-5.83.0.tar.xz"
SRC_URI[sha256sum] = "0a0f04c3a104e3c6be33adea27d80d67ad73f05d584252d4496e88da11974905"

