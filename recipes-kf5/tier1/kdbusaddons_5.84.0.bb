# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kdbusaddons-5.84.0.tar.xz"
SRC_URI[sha256sum] = "85ee6b5a341197e2df822dfb132c6338dc2648785ad75406e6416b6ad0139b28"

