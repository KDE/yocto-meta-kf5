# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kdbusaddons-5.85.0.tar.xz"
SRC_URI[sha256sum] = "a60d24de1b6dae7c11b41453570cdba6ae501310f6dfcd9e41f1ea65fd141339"

