# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kdbusaddons-5.88.0.tar.xz"
SRC_URI[sha256sum] = "5ada2a78a778f9356e259876b649d9799936a096d2d0056fccccb406a3e532de"

