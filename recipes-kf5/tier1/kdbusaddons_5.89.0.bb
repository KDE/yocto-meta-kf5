# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kdbusaddons-5.89.0.tar.xz"
SRC_URI[sha256sum] = "f0cb05178c793d6b9fd6f9a20342083a67312e493970d695914c6a1e40ef05fa"

