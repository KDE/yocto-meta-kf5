# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kdbusaddons-5.90.0.tar.xz"
SRC_URI[sha256sum] = "44e99c247c053db796ac3752f546bcc759651206f178305854bc4757fd4ac03c"

