# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kdbusaddons-5.93.0.tar.xz"
SRC_URI[sha256sum] = "cc2c74501e65b97af1849ff454e51393f3a07755c155854bdee741a006822ad9"

