# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kdbusaddons-5.94.0.tar.xz"
SRC_URI[sha256sum] = "0a1530117ccad6f1ea7b9db653bdf99adfe7f15f3f9394c3d885028f3ff4dae8"

