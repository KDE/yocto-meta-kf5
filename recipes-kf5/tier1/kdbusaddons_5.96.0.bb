# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kdbusaddons-5.96.0.tar.xz"
SRC_URI[sha256sum] = "7e50d4fa9e9d4882a7eaa7bc310aa0c099c4e7de10f53da686ec711b14680ef8"

