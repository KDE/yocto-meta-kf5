# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kdbusaddons-5.97.0.tar.xz"
SRC_URI[sha256sum] = "13c7e82914bf1e594fcaafe8a1cfdb4607bc75a58a10b5a04fead84fe412122d"

