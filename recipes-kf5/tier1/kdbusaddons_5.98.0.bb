# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kdbusaddons-5.98.0.tar.xz"
SRC_URI[sha256sum] = "0a24e2c3fc8c1e8af70bfd76439f81fa0f35fb50f1711fe22db68bc82cad8d3b"

