# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kdbusaddons-5.99.0.tar.xz"
SRC_URI[sha256sum] = "a0c7cced69719df4809a22791b4e3be27cc737fbc006c7d7f41be445dc4b32d9"

