require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "e7740b2723c2789ece5b816e74139205cc6976ef"
PV = "5.0.0"
