# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kdnssd-5.101.0.tar.xz"
SRC_URI[sha256sum] = "c65698b42e81cdf1737f3b037656654e76a1db06f58820fb02221e48d0ed3f4b"

