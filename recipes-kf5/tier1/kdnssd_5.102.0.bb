# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kdnssd-5.102.0.tar.xz"
SRC_URI[sha256sum] = "05a529a02dd191abd7c6671555c37dced0aba00eeac0784a7a14162003ac5c81"

