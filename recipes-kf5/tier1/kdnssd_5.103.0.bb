# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kdnssd-5.103.0.tar.xz"
SRC_URI[sha256sum] = "267aab6d1bdfb2be68e65c6c4efd5ba638dea6f913bc2016f187c5b8f13645ed"

