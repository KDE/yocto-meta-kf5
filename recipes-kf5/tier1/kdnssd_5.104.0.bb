# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kdnssd-5.104.0.tar.xz"
SRC_URI[sha256sum] = "3b21557d01a618e1b48fea7636952e4ce7d409af7a1875b594ad0f5373cf60fe"

