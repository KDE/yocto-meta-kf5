# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kdnssd-5.105.0.tar.xz"
SRC_URI[sha256sum] = "c565de37584666d0c786b9422efbf6134c6c43dd8940875d7dc3f3a1fc7828d4"

