# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kdnssd-5.107.0.tar.xz"
SRC_URI[sha256sum] = "155cb54351d76299c295ef859695fb280d7b74fd4daa9ac0bfc9752f7a1bd0ca"

