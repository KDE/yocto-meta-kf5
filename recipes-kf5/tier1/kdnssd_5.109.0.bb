# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kdnssd-${PV}.tar.xz"
SRC_URI[sha256sum] = "37576ac7f3b0a7a6903498e0b83e68d71d97163a31af2059b86982fd7be5883d"

