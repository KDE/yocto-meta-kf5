# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kdnssd-5.110.0.tar.xz"
SRC_URI[sha256sum] = "8548054b3d45e6871997a5c77092cd53e44319554e9146a244508953ec83aa76"

