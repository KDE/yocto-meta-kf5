# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kdnssd-5.83.0.tar.xz"
SRC_URI[sha256sum] = "6ff550e4d97d77d8e46bc6f76dfbcfcb2e2264f43144c5f9aaed7e191f502285"

