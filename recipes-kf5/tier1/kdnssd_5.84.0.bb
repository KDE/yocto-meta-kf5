# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kdnssd-5.84.0.tar.xz"
SRC_URI[sha256sum] = "a9761f167f302538aa466eb8ecf5f2c628dd07eaadb7d8a82511885a4063daab"

