# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kdnssd-5.85.0.tar.xz"
SRC_URI[sha256sum] = "1575b34bdd1fae9b2406ecc162e239d97128b6d143e3c82b028b362db1d93844"

