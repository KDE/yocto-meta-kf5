# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kdnssd-5.86.0.tar.xz"
SRC_URI[sha256sum] = "72e44e60b74954b30acdf20a07ad0fe339cddd726df5c68b8c138edac797a3a0"

