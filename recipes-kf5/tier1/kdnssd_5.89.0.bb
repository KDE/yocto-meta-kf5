# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kdnssd-5.89.0.tar.xz"
SRC_URI[sha256sum] = "50efd53ed76fbb94ff7b8d6f880024c9d66f38e2996577551774227a4678e26c"

