# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kdnssd-5.90.0.tar.xz"
SRC_URI[sha256sum] = "396b2ab400847ce28de7a29017034b2015fb9e625af1a40f24d77ca734a65f9f"

