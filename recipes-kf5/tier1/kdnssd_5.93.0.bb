# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kdnssd-5.93.0.tar.xz"
SRC_URI[sha256sum] = "dc97364f14b5867ea5bb2986f6ad3c84ab1acc952f50d460b3e9aed03f2f903b"

