# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kdnssd-5.94.0.tar.xz"
SRC_URI[sha256sum] = "28eba2ff83d92bb80eac5bb771d5d5bf40c975d4b26a74d388092b034a964863"

