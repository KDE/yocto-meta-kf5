# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kdnssd-5.96.0.tar.xz"
SRC_URI[sha256sum] = "1c1c5f6da522a639f974e71fa2364c00d52cebbaf619e2f4606b48ff88c172b4"

