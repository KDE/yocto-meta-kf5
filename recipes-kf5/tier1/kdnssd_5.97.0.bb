# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kdnssd-5.97.0.tar.xz"
SRC_URI[sha256sum] = "4d04d691c813217abc26c15654f8068687487ad6e644b57d45de19b0c8e2b452"

