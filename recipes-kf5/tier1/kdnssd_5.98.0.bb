# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kdnssd-5.98.0.tar.xz"
SRC_URI[sha256sum] = "8f6ced2da202755461552a1c5e822b4915d417ce2486e1af4d5f36161ec09271"

