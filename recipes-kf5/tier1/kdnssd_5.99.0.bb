# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kdnssd-5.99.0.tar.xz"
SRC_URI[sha256sum] = "47314f59bb3ca3cc66459afd596be561909981279c84ca64a179a7d09f582a1c"

