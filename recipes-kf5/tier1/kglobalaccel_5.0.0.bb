require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "46dc641175994185934b3231816d6a7cd48a2a71"
PV = "5.0.0"
