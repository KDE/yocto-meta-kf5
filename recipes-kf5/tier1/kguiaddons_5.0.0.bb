require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "629628028eb637a727ab54689c2dec50a68eaaca"
PV = "5.0.0"
