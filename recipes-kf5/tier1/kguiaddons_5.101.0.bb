# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kguiaddons-5.101.0.tar.xz"
SRC_URI[sha256sum] = "9894e4193b3cb7b4ed5e3a591cf12043fb87683b09db77e465aa4453c7c757b7"

