# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kguiaddons-5.102.0.tar.xz"
SRC_URI[sha256sum] = "5b1320df6aab312b647bcf8eab793631f8ca5339615ddb283810be5dbb758fab"

