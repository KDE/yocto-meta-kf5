# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kguiaddons-5.103.0.tar.xz"
SRC_URI[sha256sum] = "e63280fdefc4d82b42fc7b8e8e30c0b92e05538b00fb31086683019cc2d5b232"

