# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kguiaddons-5.104.0.tar.xz"
SRC_URI[sha256sum] = "fb8d8de25b684af6f9e9e893912664a18231486ac995d2522676018c3e93840d"

