# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kguiaddons-5.105.0.tar.xz"
SRC_URI[sha256sum] = "66318ce05ce96fc69533adae525a8aa7e11ee675646fc395b46de30fafa31af1"

