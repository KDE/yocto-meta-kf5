# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kguiaddons-5.107.0.tar.xz"
SRC_URI[sha256sum] = "ad2f6e6ca7dd3c230de54bab357e33a9c21e85a2836f63565e3b77ebf79984c1"

