# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kguiaddons-${PV}.tar.xz"
SRC_URI[sha256sum] = "207d66c3b1b2630f366cb6bab408be60e3f8299ac56be35b24a3c8f336ce7fbd"

