# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kguiaddons-5.110.0.tar.xz"
SRC_URI[sha256sum] = "2ca155dec16b7a3d7968c3b7dc01ba71c1c11d4e9a98c6217146476891ec552a"

