# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kguiaddons-5.83.0.tar.xz"
SRC_URI[sha256sum] = "32f62e593f084f53cf12b8cf78d09384f23f4010a3bb7b6abe6645616206eab9"

