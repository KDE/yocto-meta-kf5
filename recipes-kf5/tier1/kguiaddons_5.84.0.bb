# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kguiaddons-5.84.0.tar.xz"
SRC_URI[sha256sum] = "2924e91c79a91c8f2714c5f75c13c269cc95595d028d8e3613dba142ebef285d"

