# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kguiaddons-5.85.0.tar.xz"
SRC_URI[sha256sum] = "0cdad481d5564417fbcd2ee93a7c9e436bc63fb72eaad535d911b263261127b4"

