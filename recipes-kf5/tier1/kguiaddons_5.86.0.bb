# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kguiaddons-5.86.0.tar.xz"
SRC_URI[sha256sum] = "3f9834bb3d9c83ca78b45bfa70bb02aa6b4c76ba472dd886b03febc75ba43e7f"

