# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kguiaddons-5.88.0.tar.xz"
SRC_URI[sha256sum] = "5a9dba0bd5845468d5f3d2ed847ec43f2511a416bf374e001b84058fcbe02f63"

