# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kguiaddons-5.89.0.tar.xz"
SRC_URI[sha256sum] = "c1a06b7434553e300e87c5bbd9cf84dd350996e036b649179ecb60c2c99cbd9e"

