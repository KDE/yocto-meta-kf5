# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kguiaddons-5.90.0.tar.xz"
SRC_URI[sha256sum] = "9d2be477affaac6908e946b0c073d13f072a3254e8f2fe5d12d2f7c37c473455"

