# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kguiaddons-5.93.0.tar.xz"
SRC_URI[sha256sum] = "27f26392140bd1abcb86c154fd6fd87e50b2493787827b2b1cacaf76544af40a"

