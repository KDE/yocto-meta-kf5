# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kguiaddons-5.94.0.tar.xz"
SRC_URI[sha256sum] = "f23182a7268d37cbc32eaa77bdc9dddc6429a8eff912f57841f6d96c71973873"

