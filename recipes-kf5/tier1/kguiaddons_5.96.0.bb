# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kguiaddons-5.96.0.tar.xz"
SRC_URI[sha256sum] = "7bb9b94fdacd43e3f6d68986cb20ac6d0470e2a46ca813167268ffcd68b21309"

