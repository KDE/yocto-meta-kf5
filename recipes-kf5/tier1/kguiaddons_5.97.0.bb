# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kguiaddons-5.97.0.tar.xz"
SRC_URI[sha256sum] = "fb78595f0f98435f87047d662b1e124ea2cd5edd279dbccb857d4d8f06967582"

