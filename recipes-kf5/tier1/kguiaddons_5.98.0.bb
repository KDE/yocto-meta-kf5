# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kguiaddons-5.98.0.tar.xz"
SRC_URI[sha256sum] = "12dbee2c4e9b095b3167c83ab658db15f10be310229e10309db8c1890a725808"

