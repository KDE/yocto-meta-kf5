# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kholidays-5.101.0.tar.xz"
SRC_URI[sha256sum] = "44722c8053370663e4690602cdb58fed1fa9648a6dd766ecaf0800043c263473"

