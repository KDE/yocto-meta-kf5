# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kholidays-5.102.0.tar.xz"
SRC_URI[sha256sum] = "a195678a6d791c60047cf10398317a6ee301b2a18a51e0bfa4999dd7b1b63f07"

