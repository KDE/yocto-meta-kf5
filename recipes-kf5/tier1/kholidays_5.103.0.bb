# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kholidays-5.103.0.tar.xz"
SRC_URI[sha256sum] = "aaf5540546d741489665111d2265281ad7eb14c5c36543311e9fcdce6edc50cd"

