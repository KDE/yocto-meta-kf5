# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kholidays-5.104.0.tar.xz"
SRC_URI[sha256sum] = "484fe429d1b65c27da78cf0a7a8ebeafb32346d641a03c0c956119ac2ff9282d"

