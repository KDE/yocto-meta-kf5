# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kholidays-5.105.0.tar.xz"
SRC_URI[sha256sum] = "5ba80c218e3db9432a6625e9ae376ce4b4605a73e6081fd23211f07b47a28c0a"

