# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kholidays-5.107.0.tar.xz"
SRC_URI[sha256sum] = "ca5670e9d1d7e979c139d07936f00826e06cbe902ba93bf28fd342dcc4a2432c"

