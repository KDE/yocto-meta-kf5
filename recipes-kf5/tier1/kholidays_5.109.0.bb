# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kholidays-${PV}.tar.xz"
SRC_URI[sha256sum] = "025a1aa3653c787e317b6cd737793bcf2340e4fd3f07239afc1f9006c33b6f4d"

