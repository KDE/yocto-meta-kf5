# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kholidays-5.110.0.tar.xz"
SRC_URI[sha256sum] = "4c56346b5047c722e43a5449e1fef7dad2a68371b71894fcc37c2416ab54337e"

