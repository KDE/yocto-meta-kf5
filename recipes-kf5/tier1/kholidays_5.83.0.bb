# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kholidays-5.83.0.tar.xz"
SRC_URI[sha256sum] = "22c31ca5ef789b55c3c9dc145042413853b962dc976c9740078fe660ddda98c4"

