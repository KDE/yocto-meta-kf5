# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kholidays-5.84.0.tar.xz"
SRC_URI[sha256sum] = "1a63c5e3f96a4e34b51261a9ffa71294a656f75111e9c551a1e382a8366dec3b"

