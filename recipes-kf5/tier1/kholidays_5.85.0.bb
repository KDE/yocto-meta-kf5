# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kholidays-5.85.0.tar.xz"
SRC_URI[sha256sum] = "227a81d439b1d794b4c02f87e4401b43b5da6169039ca3f67834dc2f35b23d5b"

