# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kholidays-5.86.0.tar.xz"
SRC_URI[sha256sum] = "673d53f079c0338193f0467816650653c2394563548e96cc10d39afc15bd0bdb"

