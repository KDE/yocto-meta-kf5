# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kholidays-5.88.0.tar.xz"
SRC_URI[sha256sum] = "8a97a884a60bcd5bc091a833aeb40ca0c5e203389abd44e3076c1c1553bc803b"

