# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kholidays-5.89.0.tar.xz"
SRC_URI[sha256sum] = "1c956160ca1c45368b2f8a058224a4cb135f3d82759413ad3abbcbd9c6b1c067"

