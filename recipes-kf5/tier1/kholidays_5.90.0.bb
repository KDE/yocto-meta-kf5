# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kholidays-5.90.0.tar.xz"
SRC_URI[sha256sum] = "e84781ea8abb24f5dbe2b34981dcb7fa017e62f0e9911e872a534610827f33dc"

