# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kholidays-5.93.0.tar.xz"
SRC_URI[sha256sum] = "0d4a1fb823501ee73b2c4d80468777adedf93c80f36b3a680cad91cc6704b841"

