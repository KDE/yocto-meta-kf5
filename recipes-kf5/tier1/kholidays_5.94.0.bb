# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kholidays-5.94.0.tar.xz"
SRC_URI[sha256sum] = "e53735539c9d7658e3c18e0d8b0f81bc9ce27ff32a868bac32c19c12288a055d"

