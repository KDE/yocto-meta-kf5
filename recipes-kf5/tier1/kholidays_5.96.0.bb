# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kholidays-5.96.0.tar.xz"
SRC_URI[sha256sum] = "93d8b152a1fdd8afb9bba127fdcf149be0626bfcf3a220fbd7d2f0d0c5448d65"

