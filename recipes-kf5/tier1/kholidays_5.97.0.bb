# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kholidays-5.97.0.tar.xz"
SRC_URI[sha256sum] = "728f7a777c49b2748eac98a82fb8532a806804064bad0e1f2c17ea5cf7c9b82c"

