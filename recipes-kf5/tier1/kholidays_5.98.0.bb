# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kholidays-5.98.0.tar.xz"
SRC_URI[sha256sum] = "e0fe8bbd4dfabcea9a31310d4256e381ba0baf2d48c7076cbe33771fb9285c7b"

