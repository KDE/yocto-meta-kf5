# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kholidays-5.99.0.tar.xz"
SRC_URI[sha256sum] = "f8131a0d9526bc8d5dc6818f10409175e2e329a78157e64b131dda5ff52c26cc"

