require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "71bb29c73625e14e81da804a3c1fd0ff29c315e0"
PV = "5.0.0"
