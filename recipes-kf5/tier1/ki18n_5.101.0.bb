# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/ki18n-5.101.0.tar.xz"
SRC_URI[sha256sum] = "bf1530be9279d476c0531988eeb1c032e208f6010c8f00880bb5d694229fef65"

