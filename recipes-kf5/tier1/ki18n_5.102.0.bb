# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/ki18n-5.102.0.tar.xz"
SRC_URI[sha256sum] = "9ce380a9c3e40861fabe78e677c6cd826be4ced707cf87c6507251acb81c9f47"

