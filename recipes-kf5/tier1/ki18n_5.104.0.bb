# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/ki18n-5.104.0.tar.xz"
SRC_URI[sha256sum] = "fe815b9e28c680fa472c7ab56e4d7934a8915f19409734a13433797a4be14ee1"

