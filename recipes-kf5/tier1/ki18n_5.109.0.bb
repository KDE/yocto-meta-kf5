# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/ki18n-${PV}.tar.xz"
SRC_URI[sha256sum] = "dd8b6cb94b082c1e2e564199315cb08c982edb22a27ec0db481884c48b5cdf45"

