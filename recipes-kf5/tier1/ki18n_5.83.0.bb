# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/ki18n-5.83.0.tar.xz"
SRC_URI[sha256sum] = "d1bde46763240d3462df34131364c9693914a3016041e6cefb71bdcbfa4bef5e"

