# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/ki18n-5.84.0.tar.xz"
SRC_URI[sha256sum] = "603f1ee0d1e74afb0a2cc83a1415c126c59de9c977ec1632acc34fb76e976094"

