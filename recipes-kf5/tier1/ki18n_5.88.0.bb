# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/ki18n-5.88.0.tar.xz"
SRC_URI[sha256sum] = "ca204e531e0f6bbe5971a6f04a021a46ed06fbbee89a387f4a1bc86698496488"

