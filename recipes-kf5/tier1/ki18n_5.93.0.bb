# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/ki18n-5.93.0.tar.xz"
SRC_URI[sha256sum] = "c2705400d175f18612dfe1afb28dc14accf614f7cfd65409dfa7fdcde5237339"

