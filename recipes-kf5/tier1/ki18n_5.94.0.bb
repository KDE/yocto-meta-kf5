# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/ki18n-5.94.0.tar.xz"
SRC_URI[sha256sum] = "0c5a8332343570e8530469840d67c72a28a04a7257578e5a962c73824508944a"

