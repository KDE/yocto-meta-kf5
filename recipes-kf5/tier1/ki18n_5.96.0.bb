# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/ki18n-5.96.0.tar.xz"
SRC_URI[sha256sum] = "fe815cb7994f757ff92cae0ae5b739909a94d01c7272752cc56cf627db423ecb"

