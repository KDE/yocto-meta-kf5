# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/ki18n-5.97.0.tar.xz"
SRC_URI[sha256sum] = "032f6d6f78c815ab2630a559ebf4c4a3737147fb35f327d213a171acf6f81e1e"

