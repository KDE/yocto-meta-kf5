# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/ki18n-5.98.0.tar.xz"
SRC_URI[sha256sum] = "87d00d09befed44a985f1fa7d931f689e0c4c56e286d392ff6142e2ff628792c"

