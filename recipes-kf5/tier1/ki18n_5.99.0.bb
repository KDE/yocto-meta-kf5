# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/ki18n-5.99.0.tar.xz"
SRC_URI[sha256sum] = "1544dd5a002a2376f1018fee619ae2de861cd900cec312fade09e6a6943ef8ad"

