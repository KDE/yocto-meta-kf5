require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "1c99d012dbf370a09d5e2664b2d3c9a341682927"
PV = "5.0.0"
