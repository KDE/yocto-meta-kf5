# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kidletime-5.101.0.tar.xz"
SRC_URI[sha256sum] = "ddda3dc864e0e9b18f30f1bcaf79ceb7d4148391215556e26f4177882b9f1283"

