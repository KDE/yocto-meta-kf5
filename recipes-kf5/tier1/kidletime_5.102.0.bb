# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kidletime-5.102.0.tar.xz"
SRC_URI[sha256sum] = "0e23d46c2027617743c1beb6915d359846e47ffa11081c2714b7fdc3f7ce2f95"

