# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kidletime-5.103.0.tar.xz"
SRC_URI[sha256sum] = "b0f150367114ad1c97f2fca3d43643292cc0fbf87035f931fb55b63bab349842"

