# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kidletime-5.104.0.tar.xz"
SRC_URI[sha256sum] = "8a54aa7bb2794c2a1167f7b1881b0fb07149889e1f5c3329d06894c6ab188061"

