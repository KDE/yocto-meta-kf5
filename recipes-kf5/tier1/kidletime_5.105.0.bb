# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kidletime-5.105.0.tar.xz"
SRC_URI[sha256sum] = "8be6497cb52c6240f4d77d47457ec4f224fbc9aebf525330d7045981d033fb2e"

