# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kidletime-5.107.0.tar.xz"
SRC_URI[sha256sum] = "3b409a281b1212f01bd1ce99cf75b8a6a73397abe96c3a278a80f709c1a7772c"

