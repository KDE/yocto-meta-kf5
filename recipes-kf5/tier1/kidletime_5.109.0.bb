# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kidletime-${PV}.tar.xz"
SRC_URI[sha256sum] = "443b1aa6e70386787362a045c6e0a72a3b9c439b8d0414c67c550fc881222adf"

