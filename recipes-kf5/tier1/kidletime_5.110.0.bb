# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kidletime-5.110.0.tar.xz"
SRC_URI[sha256sum] = "84fc1f0f6b7d1a551aaa5f758cc4d0dcaed28663a85c8d49dd608686ce018341"

