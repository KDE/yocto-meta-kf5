# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kidletime-5.83.0.tar.xz"
SRC_URI[sha256sum] = "330e9627924f63894e3be01dd8da83580552884287b893f6d5b7cc393f86c98e"

