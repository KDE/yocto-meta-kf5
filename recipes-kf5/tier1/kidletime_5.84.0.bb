# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kidletime-5.84.0.tar.xz"
SRC_URI[sha256sum] = "645fb3aa763f3c06091c359824b80c1dedc4012e0ea34ca7382ea55180fc732a"

