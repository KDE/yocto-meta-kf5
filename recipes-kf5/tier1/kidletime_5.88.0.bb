# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kidletime-5.88.0.tar.xz"
SRC_URI[sha256sum] = "baa36125b6b4b18dbe9004431365635e63f9c9491806ca6560ebb47d7f5962c3"

