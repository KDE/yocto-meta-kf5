# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kidletime-5.89.0.tar.xz"
SRC_URI[sha256sum] = "dfe1bffde505d0266ef7e37220f7026f7128291a360e3cd7f0d426eb91f48714"

