# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kidletime-5.90.0.tar.xz"
SRC_URI[sha256sum] = "785f37141e2918a86bef801b4579c7d6c6e8299881da506263346cacc0acfcf7"

