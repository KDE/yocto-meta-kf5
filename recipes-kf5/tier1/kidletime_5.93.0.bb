# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kidletime-5.93.0.tar.xz"
SRC_URI[sha256sum] = "4d9315dfe1faaeb62eae5ba60f683483de56317826d9b8da2bd58feebcb7b7d9"

