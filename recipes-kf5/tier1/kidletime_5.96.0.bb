# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kidletime-5.96.0.tar.xz"
SRC_URI[sha256sum] = "addac76557acfcdcaf61068db204964176c6c33a14ce79daa215267b80d9f18e"

