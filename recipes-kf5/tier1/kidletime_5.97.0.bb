# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kidletime-5.97.0.tar.xz"
SRC_URI[sha256sum] = "35a10914c694a03e2f45b969edd87dc8dc72fb30c44947dd8dfa3b45efc5042b"

