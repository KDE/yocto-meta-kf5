# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kidletime-5.98.0.tar.xz"
SRC_URI[sha256sum] = "93b13854c97625a93efc00e6da12e2876a6abb48cfff8cc3ffd462a8e394abc9"

