require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "5b42b3b7870e493b04a3c9dc09de0795db5eb443"
PV = "5.0.0"
