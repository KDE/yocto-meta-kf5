# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kimageformats-5.102.0.tar.xz"
SRC_URI[sha256sum] = "a68b2c44e5d0e3e3ae75f1b8167de904a2ab1f7ea49b984be4cf01c5a46d49b4"

