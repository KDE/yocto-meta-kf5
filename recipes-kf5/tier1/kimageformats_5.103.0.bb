# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kimageformats-5.103.0.tar.xz"
SRC_URI[sha256sum] = "dd7dc417aacc9dfe74745e4dfd9750129051c36502fa1cd18b92c4035d721e7e"

