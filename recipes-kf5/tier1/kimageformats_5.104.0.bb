# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kimageformats-5.104.0.tar.xz"
SRC_URI[sha256sum] = "79f42bb4abff775b93068bd8c48eb5c31c87781c84a4ee1834b1e472d54bb45d"

