# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kimageformats-5.105.0.tar.xz"
SRC_URI[sha256sum] = "4ea6ead739f9e850aa8908e246ff2f45f505bbadba20205fb580667bab87d0fc"

