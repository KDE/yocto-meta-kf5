# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kimageformats-5.107.0.tar.xz"
SRC_URI[sha256sum] = "97258ad36bf98cd1aaeeb29c49946031f5051d9984bda9f41fda5a35ccd4d1c1"

