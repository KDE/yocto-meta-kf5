# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kimageformats-${PV}.tar.xz"
SRC_URI[sha256sum] = "15533e1ba0fa187f0da0094b8ea135f38a9cebffd9118a12fcd23003eb591687"

