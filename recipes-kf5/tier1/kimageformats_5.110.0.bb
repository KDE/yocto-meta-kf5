# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kimageformats-5.110.0.tar.xz"
SRC_URI[sha256sum] = "8d69fbd8a8fb6212bc35ee5cba45c1b5b6b3e0e864010bf235a2bd2998d07347"

