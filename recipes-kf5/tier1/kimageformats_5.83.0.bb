# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kimageformats-5.83.0.tar.xz"
SRC_URI[sha256sum] = "dc3965efbf9f2a42b78bbaea3d825b0946a27ad5fc79395cd405c858f38d8917"

