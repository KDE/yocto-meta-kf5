# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kimageformats-5.84.0.tar.xz"
SRC_URI[sha256sum] = "badd15c93c1af2c6ab7f156245186a2223a184523070c6614328486e186eedf7"

