# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kimageformats-5.85.0.tar.xz"
SRC_URI[sha256sum] = "50a61ac010acbde64f470cb3877403ca5aa11f70b9e54ede0a3bc09b02d40799"

