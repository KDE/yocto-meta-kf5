# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kimageformats-5.86.0.tar.xz"
SRC_URI[sha256sum] = "a5b92d6ea22911a68c3fc52913fc0840e4bd5943779c504ad4bcd620a0b9a985"

