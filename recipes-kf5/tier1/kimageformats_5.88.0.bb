# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kimageformats-5.88.0.tar.xz"
SRC_URI[sha256sum] = "eee708f338fa55a5780acb6cb01dced092446f3d4f66b9e001d61fbfe2b588b5"

