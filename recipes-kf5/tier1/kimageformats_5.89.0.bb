# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kimageformats-5.89.0.tar.xz"
SRC_URI[sha256sum] = "dcee152a0b8fc0b74e657bc5e07cbeb007761555d6a2519503d4e94f49a06ed4"

