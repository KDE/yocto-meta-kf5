# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kimageformats-5.90.0.tar.xz"
SRC_URI[sha256sum] = "3bec943c0eee38f34dba4dcf8c0e5056e25fc309691dbbb002c241e0e9847164"

