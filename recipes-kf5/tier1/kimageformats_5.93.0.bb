# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kimageformats-5.93.0.tar.xz"
SRC_URI[sha256sum] = "15b0ed9de57af95979e0e40496b980f243cd81e2a400d5f64d12478e1dddc7d0"

