# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kimageformats-5.94.0.tar.xz"
SRC_URI[sha256sum] = "b189626c091dc9959d586a229c47ca36443b77d79706476ff89a50f9e8774e54"

