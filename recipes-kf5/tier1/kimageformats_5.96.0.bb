# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kimageformats-5.96.0.tar.xz"
SRC_URI[sha256sum] = "a5ce354ef2d0146609e0a681e74da078b0592195e304d45670e5e698d5167435"

