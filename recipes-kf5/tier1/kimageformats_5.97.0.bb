# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kimageformats-5.97.0.tar.xz"
SRC_URI[sha256sum] = "eb83362fb98b2a9eba02c434fe5ab137a29f9a33101553adeb3e12d88bc05211"

