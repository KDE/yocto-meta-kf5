# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kimageformats-5.98.0.tar.xz"
SRC_URI[sha256sum] = "de594d949a79ffd3729fc84e9f659d64a2d41849ff5684472153620169c8926c"

