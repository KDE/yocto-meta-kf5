# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kimageformats-5.99.0.tar.xz"
SRC_URI[sha256sum] = "06e636d4fe03d8d1b0bfed728d00c83fa639e2990fd5664a7101bd77621db1ee"

