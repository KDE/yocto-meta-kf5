require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "a90e289399faa4a174f29b71f6fea42ce575095c"
PV = "5.0.0"
