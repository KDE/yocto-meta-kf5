# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kitemmodels-5.102.0.tar.xz"
SRC_URI[sha256sum] = "52f773f8969f07dd42c0f9afc5f9a604c8c450915228ada70b1058bae87938a6"

