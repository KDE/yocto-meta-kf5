# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kitemmodels-5.103.0.tar.xz"
SRC_URI[sha256sum] = "356c4d6fa808f2cad93629e7362b0cc95e0217b116ac9e07429c8f0d18a370cb"

