# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kitemmodels-5.105.0.tar.xz"
SRC_URI[sha256sum] = "d28798439e4f6a1de3388e1fa0b7aefa0002b1902b62841e70551fcba3791523"

