# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kitemmodels-5.107.0.tar.xz"
SRC_URI[sha256sum] = "b7f5aae6a5d0605f737ab3e993f9a195ba164f6f89672013e26b1276808a11af"

