# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kitemmodels-${PV}.tar.xz"
SRC_URI[sha256sum] = "16f0e59a76368524ebdc90cce62e4cead41142953889312aab0ee157b53ab0f0"

