# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kitemmodels-5.110.0.tar.xz"
SRC_URI[sha256sum] = "123a7f4511f74f4a20aebf4d7194bfe46c71bdf3d3c3cc4864d71262c6a8fe19"

