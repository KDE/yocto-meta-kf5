# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kitemmodels-5.84.0.tar.xz"
SRC_URI[sha256sum] = "da66a5608d2cffc6f465e963b3364e5faa81d88b19ca867e1004ca5202db29ec"

