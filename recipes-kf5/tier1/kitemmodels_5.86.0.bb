# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kitemmodels-5.86.0.tar.xz"
SRC_URI[sha256sum] = "4fd951a84e6c634601b90802f8ab903cd187643785d8bb3e5556af77f586f216"

