# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kitemmodels-5.88.0.tar.xz"
SRC_URI[sha256sum] = "60f4e112f6862f7e0536e625ce53ec67c77c873d9802ef92f485b5d752b383fe"

