# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kitemmodels-5.90.0.tar.xz"
SRC_URI[sha256sum] = "f12ffc52148cc94715b038b5c6e210669192a877f4678ff8e56bea795ca4ff38"

