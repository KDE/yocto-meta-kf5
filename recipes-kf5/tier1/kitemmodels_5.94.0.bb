# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kitemmodels-5.94.0.tar.xz"
SRC_URI[sha256sum] = "705ff2b97502b2ba436f9371b559e47f2a7634bf5b06d26c8243387d6a084f89"

