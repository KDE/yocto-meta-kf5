# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kitemmodels-5.96.0.tar.xz"
SRC_URI[sha256sum] = "5b30a75b34e5d6fd39689f49b408af2e19c557454b4db0ffff07b4f5b673d3c8"

