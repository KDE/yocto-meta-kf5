# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kitemmodels-5.97.0.tar.xz"
SRC_URI[sha256sum] = "7c5d1bab28b864dd4f9a9cdecfbc35d90ca94965ed0f6c79eead6d8aa854b46f"

