# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kitemmodels-5.98.0.tar.xz"
SRC_URI[sha256sum] = "26e8a55d252debaf71b3d7bf9a4ea388ee14dfffc3542f7c9763204aabe43afd"

