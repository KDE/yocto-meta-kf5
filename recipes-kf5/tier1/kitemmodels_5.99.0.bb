# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kitemmodels-5.99.0.tar.xz"
SRC_URI[sha256sum] = "37ce9d8dc6670cf3966dabb26935d74e6e22498157a2bad560e0dd22f36ca2fc"

