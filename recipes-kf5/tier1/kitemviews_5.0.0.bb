require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "73efe3cc9fceffa7dbfd75f975d2dce673f109e9"
PV = "5.0.0"
