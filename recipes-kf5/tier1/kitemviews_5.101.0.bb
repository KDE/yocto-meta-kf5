# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kitemviews-5.101.0.tar.xz"
SRC_URI[sha256sum] = "aca259eeff2dde1434cdf3ff3d979e9b17dd55bad15dd7341f92700cf8418fb1"

