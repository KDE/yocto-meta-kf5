# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kitemviews-5.102.0.tar.xz"
SRC_URI[sha256sum] = "3e19ea06b8d4e11469840b4b8709a8553c03f12915ae3c3504f2f85440c561b0"

