# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kitemviews-5.103.0.tar.xz"
SRC_URI[sha256sum] = "8069046d455ea404f67403b057a6060055038a570c5a8307712128dd52649c4e"

