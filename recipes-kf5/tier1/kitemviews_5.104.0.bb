# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kitemviews-5.104.0.tar.xz"
SRC_URI[sha256sum] = "94920dc68c187319fa79c64e194e9ebecaef8c97fc4bd6aba342c18bc75a48bc"

