# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kitemviews-5.105.0.tar.xz"
SRC_URI[sha256sum] = "25dac0803149156e088b51db1fc717b2c95bf373becc2625b031d0aca06235cd"

