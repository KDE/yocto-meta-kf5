# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kitemviews-5.107.0.tar.xz"
SRC_URI[sha256sum] = "d5460cee8e9b08c1c0472e88e07bbe04d33cf69da6faf45febd9680972a00b17"

