# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kitemviews-${PV}.tar.xz"
SRC_URI[sha256sum] = "4d59fbb9f07737a9d104abf6678e3ac3433885eca379d180b1b22f2514d8c2a9"

