# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kitemviews-5.110.0.tar.xz"
SRC_URI[sha256sum] = "d763b6939662dc9f23781c318bdce2282f5c1174e0a7d091c26a6506ecf50bdb"

