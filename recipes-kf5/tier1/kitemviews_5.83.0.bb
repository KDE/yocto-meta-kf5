# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kitemviews-5.83.0.tar.xz"
SRC_URI[sha256sum] = "bc1b509954bfb7e9614a882f53903d8d69843f804f3ca842be2cc17aee7de682"

