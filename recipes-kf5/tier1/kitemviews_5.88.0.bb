# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kitemviews-5.88.0.tar.xz"
SRC_URI[sha256sum] = "276a27bd556e977d31666846736382f75429a0632a20a01406257dcfcfce70cb"

