# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kitemviews-5.89.0.tar.xz"
SRC_URI[sha256sum] = "da62957a7cd3f29d92f0077f537e2a983e2152795a40cc24ad6f9b3d5f2016a0"

