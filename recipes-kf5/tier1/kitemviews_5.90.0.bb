# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kitemviews-5.90.0.tar.xz"
SRC_URI[sha256sum] = "f757982856c62031313d724bc639319b9fc60b647b91aa8667b22bd577414283"

