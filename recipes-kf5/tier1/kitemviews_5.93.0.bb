# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kitemviews-5.93.0.tar.xz"
SRC_URI[sha256sum] = "93f01dec3b795b28cc6f6859873ebb941a9504eaafd13ff9f72b987d71e55abf"

