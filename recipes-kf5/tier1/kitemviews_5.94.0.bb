# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kitemviews-5.94.0.tar.xz"
SRC_URI[sha256sum] = "5b75334b719ce07f4aa33236ef4bd11829504ff381670818ef57a7526938b52e"

