# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kitemviews-5.96.0.tar.xz"
SRC_URI[sha256sum] = "8b9a6404b5a84c9142008c3fe840c7ba4a3fbf8f77253a5105e4512ecd1726f3"

