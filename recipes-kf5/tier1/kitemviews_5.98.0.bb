# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kitemviews-5.98.0.tar.xz"
SRC_URI[sha256sum] = "b221a958ffb89c0acd9b49b399ab5f966d5b4f6a98e479de9aaf6d6d23c5cf9c"

