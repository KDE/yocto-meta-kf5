# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kitemviews-5.99.0.tar.xz"
SRC_URI[sha256sum] = "1161d0ed34142fcaf6bc15d26dd91f2d593e4094023570c6fb13df253548f98d"

