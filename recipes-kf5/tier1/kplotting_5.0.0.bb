require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "1ef35022e0c8a1ad87783d7338af7b90672694c6"
PV = "5.0.0"
