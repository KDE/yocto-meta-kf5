# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kplotting-5.101.0.tar.xz"
SRC_URI[sha256sum] = "f1d04d1f51aedf162e2acdb1721ab7780aa1d5f89c50d050600291ac8fc15018"

