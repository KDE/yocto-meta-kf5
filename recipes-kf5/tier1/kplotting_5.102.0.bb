# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kplotting-5.102.0.tar.xz"
SRC_URI[sha256sum] = "1e6bcee1822bce79b0957686327342729e2faccf59f97aa8d1e4ffc438a908e3"

