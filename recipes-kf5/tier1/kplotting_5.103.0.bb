# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kplotting-5.103.0.tar.xz"
SRC_URI[sha256sum] = "bb3553268103eb1c0ecc10b211f78ebbf18b221757980978e9c8ff2c07086b92"

