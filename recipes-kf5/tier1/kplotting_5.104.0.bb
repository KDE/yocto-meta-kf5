# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kplotting-5.104.0.tar.xz"
SRC_URI[sha256sum] = "5df94c70aa0512baef7662fc7c244b52de9f278d17f2558ff31f3665ce243f09"

