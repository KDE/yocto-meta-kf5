# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kplotting-5.105.0.tar.xz"
SRC_URI[sha256sum] = "c9ce3514dfff5bc1432c26e5b9b0f9a4727edd18979a5745e8537a3c0edf100b"

