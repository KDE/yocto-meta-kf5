# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kplotting-5.107.0.tar.xz"
SRC_URI[sha256sum] = "4c6c3dba2242e2a0ed053db8083dd35fa7e5de2d31e5e142c0beda9f750ed33e"

