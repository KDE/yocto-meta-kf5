# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kplotting-${PV}.tar.xz"
SRC_URI[sha256sum] = "d2115407bc7fffd06b3617d52eb6029e4b44a5fe593d662f37749031a0e20614"

