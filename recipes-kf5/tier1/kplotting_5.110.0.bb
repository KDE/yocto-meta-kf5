# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kplotting-5.110.0.tar.xz"
SRC_URI[sha256sum] = "7335888e62b3fae10b10d654e07d006cd0aab0432cb4a6313224f40766f27fb9"

