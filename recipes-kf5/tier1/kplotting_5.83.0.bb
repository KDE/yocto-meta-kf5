# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kplotting-5.83.0.tar.xz"
SRC_URI[sha256sum] = "1249278aa68cb19f4e1a8513ccfa59685abe1cb118d930b9d628f19419719641"

