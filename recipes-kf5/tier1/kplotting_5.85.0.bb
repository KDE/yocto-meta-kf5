# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kplotting-5.85.0.tar.xz"
SRC_URI[sha256sum] = "aafdcac762a9ce52ba0ea2040a99a919439a043752d7f4b78aa0fce84460134a"

