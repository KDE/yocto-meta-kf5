# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kplotting-5.88.0.tar.xz"
SRC_URI[sha256sum] = "b7b5438bfcf113e13977861644e29871552ec337a100b99d9eba9e5cf6a42a41"

