# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kplotting-5.89.0.tar.xz"
SRC_URI[sha256sum] = "da729d759f472753dcdc144696913f7c0b97a26697f25d684dcb0a2acbfe58ab"

