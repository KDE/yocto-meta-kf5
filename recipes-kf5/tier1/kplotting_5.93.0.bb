# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kplotting-5.93.0.tar.xz"
SRC_URI[sha256sum] = "586d1b694213f55259ffb6a96a10648baff6e3ce45c58d7c44734d6096b6a26d"

