# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kplotting-5.94.0.tar.xz"
SRC_URI[sha256sum] = "783d6d618601d58077c4ac7920a579af7b877b26a64a6f453570da36b57606aa"

