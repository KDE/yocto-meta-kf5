# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kplotting-5.96.0.tar.xz"
SRC_URI[sha256sum] = "090e3b25fd2bfcb37f5a9369163460300a57eef705198dae8decb79181111dfb"

