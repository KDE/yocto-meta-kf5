# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kplotting-5.98.0.tar.xz"
SRC_URI[sha256sum] = "4208fecb5e893ab0825edc70d3c3912254bb6fbe49e9d7f40d9b29d303f5df42"

