# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kplotting-5.99.0.tar.xz"
SRC_URI[sha256sum] = "d85bf4020c444b5d377effcff71197a12e15bbdeb3fbc3dd58444be702fcb47b"

