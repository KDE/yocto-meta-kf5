# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kquickcharts-5.101.0.tar.xz"
SRC_URI[sha256sum] = "fdb16c94102380d397d02adf0ad2962fb1b4136b82c63291db31a95694fed73a"

