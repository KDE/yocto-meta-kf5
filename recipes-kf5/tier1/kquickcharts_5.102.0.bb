# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kquickcharts-5.102.0.tar.xz"
SRC_URI[sha256sum] = "8064f9a222a0d1e55c6c09317594dd609df28314ba5e7549f168c459be1c9070"

