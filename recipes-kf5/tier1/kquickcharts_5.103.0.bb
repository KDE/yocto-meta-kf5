# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kquickcharts-5.103.0.tar.xz"
SRC_URI[sha256sum] = "a8ad8e1fbd0cf96ff97e9637eb98970c312f0e7401a3f137c65145e39ab61da5"

