# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kquickcharts-5.104.0.tar.xz"
SRC_URI[sha256sum] = "d9d0128545c83c10848fcdb29507fe817899f956d4461ed8a40edf5f9d84e325"

