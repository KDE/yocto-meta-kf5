# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kquickcharts-5.105.0.tar.xz"
SRC_URI[sha256sum] = "8a24080bcbe3d74e65c4d64e3cf51255fc9d41d677ba78360e1a0f8684b2c903"

