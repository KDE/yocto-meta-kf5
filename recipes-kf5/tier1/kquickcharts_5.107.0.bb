# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kquickcharts-5.107.0.tar.xz"
SRC_URI[sha256sum] = "942c737225470787baa25dc9b3e231eebbcce373e3b65f82df3223d6fbb4b9f7"

