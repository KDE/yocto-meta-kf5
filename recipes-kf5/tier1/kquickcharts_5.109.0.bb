# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kquickcharts-${PV}.tar.xz"
SRC_URI[sha256sum] = "743387f56359b571708c0fe68fa4c12b98e599dd68659e8014e8f6ba3dd9a1ad"

