# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kquickcharts-5.110.0.tar.xz"
SRC_URI[sha256sum] = "bbc897c701dc6d356a316d17e4f71cd90bc62dffadd5ea8ee5a68a0eabb61d69"

