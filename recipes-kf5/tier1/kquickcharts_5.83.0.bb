# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kquickcharts-5.83.0.tar.xz"
SRC_URI[sha256sum] = "662aa1b0a781acea2e263029eb9be270847186596faaa59037f127735b9fa356"

