# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kquickcharts-5.84.0.tar.xz"
SRC_URI[sha256sum] = "afb11dca1bfefd3b503df21181ce19e10769d9e4079b9eea9489353437b30107"

