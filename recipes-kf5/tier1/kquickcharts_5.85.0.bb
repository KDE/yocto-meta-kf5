# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kquickcharts-5.85.0.tar.xz"
SRC_URI[sha256sum] = "ae132e87d8b9ca6c927018d973f29cdc33d41ca387ee0911be887839f1c8cbc2"

