# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kquickcharts-5.86.0.tar.xz"
SRC_URI[sha256sum] = "07437496afc19263268f937d5b24a303fbd19356d3367f5f03e0a2342df30db0"

