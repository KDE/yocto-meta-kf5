# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kquickcharts-5.88.0.tar.xz"
SRC_URI[sha256sum] = "5c04438fda04767f4fddbb28dd3e4db3bae1d4777a6b8e6dc73edfd4bbd87f88"

