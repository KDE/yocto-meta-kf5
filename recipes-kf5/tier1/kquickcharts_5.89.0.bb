# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kquickcharts-5.89.0.tar.xz"
SRC_URI[sha256sum] = "21c123052aee27b1dfa02561bbe9962366f1d39c0169ced3833f486142905e17"

