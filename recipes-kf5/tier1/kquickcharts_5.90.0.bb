# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kquickcharts-5.90.0.tar.xz"
SRC_URI[sha256sum] = "d115bc31f10ba8e86b2d68e759890ee2cfa141612d30df5370e60fb032dfc9ed"

