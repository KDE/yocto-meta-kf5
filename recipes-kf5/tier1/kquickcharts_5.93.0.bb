# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kquickcharts-5.93.0.tar.xz"
SRC_URI[sha256sum] = "24346ac484d1d785bff27e0de5d29a7f7d3d73568074f8bdaeb869ff1004a848"

