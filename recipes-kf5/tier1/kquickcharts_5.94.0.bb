# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kquickcharts-5.94.0.tar.xz"
SRC_URI[sha256sum] = "3065fabdb4938b68194060794abc90feac19e73dcb7648591c58e2c9cfea9528"

