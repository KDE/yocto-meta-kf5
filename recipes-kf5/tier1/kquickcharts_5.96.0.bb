# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kquickcharts-5.96.0.tar.xz"
SRC_URI[sha256sum] = "72e096dad12cadeb2f89bebebdf906d5312dc2f8479ff36750ae8b33bbaba9e9"

