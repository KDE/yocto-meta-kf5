# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kquickcharts-5.97.0.tar.xz"
SRC_URI[sha256sum] = "c12a245bfe92b92be4a8af4c12234ee55270b3b148720097c58b6f388a9f5fec"

