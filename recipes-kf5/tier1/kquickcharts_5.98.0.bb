# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kquickcharts-5.98.0.tar.xz"
SRC_URI[sha256sum] = "13caf8ad428fd96fb9c57815b8eba32586a72d65b02effbacaf14b869c2f94f6"

