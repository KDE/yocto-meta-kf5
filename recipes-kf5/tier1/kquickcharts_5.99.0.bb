# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kquickcharts-5.99.0.tar.xz"
SRC_URI[sha256sum] = "69612537175cde6ece727f43a9a6fa557d27bd7e2ab38123ab2a24c29394c02c"

