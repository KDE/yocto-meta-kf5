# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kwayland-5.101.0.tar.xz"
SRC_URI[sha256sum] = "39c1866ed2a15235bf9df02881ed2e8cd805d50d696bcdc9fe157e54b52def63"

