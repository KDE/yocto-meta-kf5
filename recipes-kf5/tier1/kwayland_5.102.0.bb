# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kwayland-5.102.0.tar.xz"
SRC_URI[sha256sum] = "8626f4a7202b5c2eb8b10cb9b75e2a9e708be845ef37c271d4cd112a6f02a1cc"

