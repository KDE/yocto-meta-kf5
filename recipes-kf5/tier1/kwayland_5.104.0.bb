# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kwayland-5.104.0.tar.xz"
SRC_URI[sha256sum] = "05eb60288e85cdbaef4acf8d3b3b1bb4a814d2cf0ce7011e0d10cbf193bfe076"

