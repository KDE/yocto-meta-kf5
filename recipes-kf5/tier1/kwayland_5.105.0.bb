# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kwayland-5.105.0.tar.xz"
SRC_URI[sha256sum] = "017de24dc140541690b80cbd4b34d5f4b14c9ff5a2b355a08d5657af1a52348e"

