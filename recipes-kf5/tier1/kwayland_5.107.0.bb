# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kwayland-5.107.0.tar.xz"
SRC_URI[sha256sum] = "855c21176788ea418603500dfd0547c5b01340a79d86d68548b67bb1d3961049"

