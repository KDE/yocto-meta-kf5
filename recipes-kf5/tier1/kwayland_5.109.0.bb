# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kwayland-${PV}.tar.xz"
SRC_URI[sha256sum] = "d88b266938ed080496cd7f4c07a4f5d9c5e4d952aa13ef823bfec6af610925de"

