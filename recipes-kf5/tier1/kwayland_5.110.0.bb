# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kwayland-5.110.0.tar.xz"
SRC_URI[sha256sum] = "0565041ef0ab6aec2d2afbe513c79d5c56c07d03c98233ca82103abcb9dffd3d"

