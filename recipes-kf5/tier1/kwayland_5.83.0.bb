# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kwayland-5.83.0.tar.xz"
SRC_URI[sha256sum] = "8ccc71f363f93807ea8cbf7d07310a6e9f45a7085e9ee68d2f11d768453dfab9"

