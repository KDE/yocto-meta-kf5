# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kwayland-5.84.0.tar.xz"
SRC_URI[sha256sum] = "fa084514b6e912c84194ff52e9ff3c834c0e12c35f10490b2103cbe5265ef5d2"

