# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kwayland-5.85.0.tar.xz"
SRC_URI[sha256sum] = "621bb4cf10fa46d36cd2fd2c6b4e0a3bf3c4a61a9bb84418cc329d3d16bedf69"

