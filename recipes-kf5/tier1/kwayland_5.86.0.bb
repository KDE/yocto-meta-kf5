# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kwayland-5.86.0.tar.xz"
SRC_URI[sha256sum] = "863b41de1b3a22d129b01a05b15fd113bf56f4c703dd9addef49c54c3b253da3"

