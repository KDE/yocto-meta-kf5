# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kwayland-5.88.0.tar.xz"
SRC_URI[sha256sum] = "5015f330eca73ded1f0f38046832925848e2de15c0f4490667c97c61d7a0463b"

