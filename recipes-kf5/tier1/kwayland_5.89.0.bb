# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kwayland-5.89.0.tar.xz"
SRC_URI[sha256sum] = "525ceab76adb10cbd221b16def7a9d043def3bdfc2a9a1d1a378b9b892ff04eb"

