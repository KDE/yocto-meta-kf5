# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kwayland-5.90.0.tar.xz"
SRC_URI[sha256sum] = "1163e049c4b1099d75999913f6d14f62423962bb4d938764420897647a26ee58"

