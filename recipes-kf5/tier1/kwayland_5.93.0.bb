# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kwayland-5.93.0.tar.xz"
SRC_URI[sha256sum] = "1648a273ad1c0c1895a0edff9a3e97eb151e1e3533362e0f01d72706ac0a7abe"

