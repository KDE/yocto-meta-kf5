# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kwayland-5.94.0.tar.xz"
SRC_URI[sha256sum] = "b2a4d8e1b4d81ce798c991cfb34210ba095f6406a37f4714ae3ab64abaca2636"

