# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kwayland-5.96.0.tar.xz"
SRC_URI[sha256sum] = "eb1f4eb5a3891be41d4534f4617ff396b0933a2de7ee17dce6bbf37b63d49635"

