# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kwayland-5.97.0.tar.xz"
SRC_URI[sha256sum] = "e571016c89cccd5ae1a455c8f2abe59f8edab787e3cd7a165059bf365130ca3c"

