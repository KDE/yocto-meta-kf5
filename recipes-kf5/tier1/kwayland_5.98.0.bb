# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kwayland-5.98.0.tar.xz"
SRC_URI[sha256sum] = "1c171ddf9af0e257781ba245f5720da39fc89170fb6a7516ceb00f53df280930"

