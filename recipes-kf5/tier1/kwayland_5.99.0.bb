# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kwayland-5.99.0.tar.xz"
SRC_URI[sha256sum] = "a7be2125e3a833e99ad9405a03d4f9bec0d4c83c23898406da1daaf068dd65a2"

