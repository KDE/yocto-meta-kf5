require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "1c06448e7997f70e2174c2fdc8b6bdfbef44d56d"
PV = "5.0.0"
