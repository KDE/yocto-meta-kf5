# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kwidgetsaddons-5.101.0.tar.xz"
SRC_URI[sha256sum] = "78913d3303e94329db964bf072b9e565bd582fbbd026310dce6e994c8d083823"

