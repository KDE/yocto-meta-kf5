# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kwidgetsaddons-5.102.0.tar.xz"
SRC_URI[sha256sum] = "51d69722986355df6fde5eb2d05379469d01c8dc29577370bc589c263cb2d6d2"

