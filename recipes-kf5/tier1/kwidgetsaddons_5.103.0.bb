# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kwidgetsaddons-5.103.0.tar.xz"
SRC_URI[sha256sum] = "4c08cc7e8b28d1fbbf2804b44b534c66173b784457c4ca04b5609178e68c6441"

