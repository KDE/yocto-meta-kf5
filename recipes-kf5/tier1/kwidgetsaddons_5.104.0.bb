# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kwidgetsaddons-5.104.0.tar.xz"
SRC_URI[sha256sum] = "4abbb552cd43e51ad2070d8780ca7112e2c9771c2258734ae4a97712b9123120"

