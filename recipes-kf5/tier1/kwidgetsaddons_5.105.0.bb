# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kwidgetsaddons-5.105.0.tar.xz"
SRC_URI[sha256sum] = "adc8c9dedc790b9ee615295c18345efddc66ab0a69d6c0cbcc8bd5df9d6a7f1e"

