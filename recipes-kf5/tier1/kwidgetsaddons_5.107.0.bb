# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kwidgetsaddons-5.107.0.tar.xz"
SRC_URI[sha256sum] = "0fa19b9933c3f5553d16bb38b0d9f6fe0a290d58b70e7debf45714102ce887c9"

