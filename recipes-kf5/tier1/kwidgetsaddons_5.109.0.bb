# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kwidgetsaddons-${PV}.tar.xz"
SRC_URI[sha256sum] = "d68072f9f351b71a09c86f2856aaa6b6883e4681e542111c42faa1219692e2e2"

