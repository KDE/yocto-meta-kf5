# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kwidgetsaddons-5.110.0.tar.xz"
SRC_URI[sha256sum] = "ca74b0e9b1a937ee6f91ced70f16b41489d4bab1aba6c8ef485bc8928186d7b3"

