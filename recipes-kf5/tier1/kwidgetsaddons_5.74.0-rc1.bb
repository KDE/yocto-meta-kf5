# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require .inc
SRCREV = "v"
