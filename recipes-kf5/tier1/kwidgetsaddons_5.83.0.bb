# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kwidgetsaddons-5.83.0.tar.xz"
SRC_URI[sha256sum] = "4523d36acdc964a49e8cb2ec31386a1e64357105354351a257fb685dc6f4411d"

