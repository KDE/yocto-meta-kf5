# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kwidgetsaddons-5.84.0.tar.xz"
SRC_URI[sha256sum] = "778e63b0d2e7c8db472e40a95e2338c1270ac6222679a5023a170f35625dcef5"

