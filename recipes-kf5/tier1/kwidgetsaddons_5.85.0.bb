# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kwidgetsaddons-5.85.0.tar.xz"
SRC_URI[sha256sum] = "61646fff0c2349bacbf3042f3aaaab460b8939b35157a72973885099d8160490"

