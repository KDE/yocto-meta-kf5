# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kwidgetsaddons-5.88.0.tar.xz"
SRC_URI[sha256sum] = "07f11f4b62abe1299e3a9e45c8e09a0a01125164a0df7df58148393f6bbba311"

