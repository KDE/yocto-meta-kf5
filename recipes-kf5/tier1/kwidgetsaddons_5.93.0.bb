# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kwidgetsaddons-5.93.0.tar.xz"
SRC_URI[sha256sum] = "9c35e17d8c6faae58bfd48180bf968b813e6bfe2d49041b3285f8e326842a410"

