# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kwidgetsaddons-5.94.0.tar.xz"
SRC_URI[sha256sum] = "678eed15c65d6298a5f720bc6dec1a6eed4e742431f7210a1d6bad261a003d32"

