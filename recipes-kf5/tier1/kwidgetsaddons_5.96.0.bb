# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kwidgetsaddons-5.96.0.tar.xz"
SRC_URI[sha256sum] = "39a163c1e5fb1cee8de063f7b1eae279ecb2f11319594f815554298c6c9eebc5"

