# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kwidgetsaddons-5.97.0.tar.xz"
SRC_URI[sha256sum] = "7ac0c7e429036829fb430bc762ee58cb54f35c5ef955371f74fdd42376b6ac17"

