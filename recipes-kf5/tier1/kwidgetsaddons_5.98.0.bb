# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kwidgetsaddons-5.98.0.tar.xz"
SRC_URI[sha256sum] = "d9ab562740c92c57d49af125ec8cda10e2b1c4bab84428af68412fc1499cfc84"

