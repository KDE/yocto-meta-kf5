# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kwidgetsaddons-5.99.0.tar.xz"
SRC_URI[sha256sum] = "5acda26e2e5bec52b563d1507b706ea5bbe341ab4ae9bdfa84e892bbf8cd9269"

