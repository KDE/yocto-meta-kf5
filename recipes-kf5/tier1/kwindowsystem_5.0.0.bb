require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "5dcdca311dcbad5f88cb0ae8c0c329c4b379b773"
PV = "5.0.0"
