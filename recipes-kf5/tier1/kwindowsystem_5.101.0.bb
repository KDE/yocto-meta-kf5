# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kwindowsystem-5.101.0.tar.xz"
SRC_URI[sha256sum] = "ef6b9e733e320be63a4557da0453b1a8ea81519e01c1737eff69b66401302eb8"

