# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kwindowsystem-5.102.0.tar.xz"
SRC_URI[sha256sum] = "d90c9ba491c9af634f09229f1349a9ad3a2cdce92793275a5e8de357d3aa68e1"

