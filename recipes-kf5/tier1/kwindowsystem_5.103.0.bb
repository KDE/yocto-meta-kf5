# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kwindowsystem-5.103.0.tar.xz"
SRC_URI[sha256sum] = "ec6af8efd4399d140929b1a057bff8c679210d98fd26f309fdf8f89fccbf13a5"

