# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kwindowsystem-5.104.0.tar.xz"
SRC_URI[sha256sum] = "6b10ee354ebb7d2dfd6baa1374929d30811f8169c8233e55849e31e38e6af81a"

