# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kwindowsystem-5.105.0.tar.xz"
SRC_URI[sha256sum] = "40f8032edda348ce2a1ecb5dfe61a8493bec0f68ce93141c3721b72090a6f44a"

