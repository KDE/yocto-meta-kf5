# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kwindowsystem-5.107.0.tar.xz"
SRC_URI[sha256sum] = "a3aa7c3c82f70f6d347c489af45e0e4277fb792fb1b1fc1dd9a6dbb73ec6931e"

