# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kwindowsystem-5.110.0.tar.xz"
SRC_URI[sha256sum] = "e00860e592fcee42c18e6da351b310cbb1358a45d9424f31ffe9e33fb29d6a50"

