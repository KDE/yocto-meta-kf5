# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kwindowsystem-5.83.0.tar.xz"
SRC_URI[sha256sum] = "69af314db832f4dcc6c0edfbe79ed67b145283a95a189a5b81c8f886b44ccd61"

