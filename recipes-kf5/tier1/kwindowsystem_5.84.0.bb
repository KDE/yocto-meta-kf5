# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kwindowsystem-5.84.0.tar.xz"
SRC_URI[sha256sum] = "cf81e7f318eab437d12e822f6e04331ec1c76d15df56bb792e4460758944caa5"

