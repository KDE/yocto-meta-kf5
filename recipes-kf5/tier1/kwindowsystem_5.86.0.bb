# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kwindowsystem-5.86.0.tar.xz"
SRC_URI[sha256sum] = "86b88730c9a6f971ad0c8115879e9777ae503bef13323ffb53e42b2442936595"

