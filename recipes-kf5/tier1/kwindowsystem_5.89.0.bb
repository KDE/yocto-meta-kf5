# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kwindowsystem-5.89.0.tar.xz"
SRC_URI[sha256sum] = "98a832f49ac8c08d1dfd1cef0717750c6013e6cde06c8bf87b66e8b3aa381bc0"

