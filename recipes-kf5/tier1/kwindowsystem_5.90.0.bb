# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kwindowsystem-5.90.0.tar.xz"
SRC_URI[sha256sum] = "454503b913f0e0b2db733e9ba8e5be701d1233d1610d664ea363a0d90c52473a"

