# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kwindowsystem-5.96.0.tar.xz"
SRC_URI[sha256sum] = "fd773e38bb971e30e9f09583560c2d44638c4d47223ef37176cdd23ae81f8bc6"

