# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kwindowsystem-5.98.0.tar.xz"
SRC_URI[sha256sum] = "814a0e5506f794373840b2f0cb1fae1e3540b34e95b438e7edb9d2c87aed870a"

