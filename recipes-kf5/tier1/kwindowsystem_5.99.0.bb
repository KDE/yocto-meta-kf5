# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kwindowsystem-5.99.0.tar.xz"
SRC_URI[sha256sum] = "f4d13fbf562c05075bb59f997a0de567f96c008a379b7c796d2ca26c01a7f877"

