# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/modemmanager-qt-5.101.0.tar.xz"
SRC_URI[sha256sum] = "c893ce4dec6f078773c5472e082ec64e923cc0b5bd19f4ec1b00e8e2c677b006"

