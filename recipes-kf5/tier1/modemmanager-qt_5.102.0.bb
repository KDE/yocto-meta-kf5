# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/modemmanager-qt-5.102.0.tar.xz"
SRC_URI[sha256sum] = "e6a8b156814b7a6ddfe354233a65be476c85a552f7266994e5fe3bc46a3fb7a4"

