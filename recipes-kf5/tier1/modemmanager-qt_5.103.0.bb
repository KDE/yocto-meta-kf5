# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/modemmanager-qt-5.103.0.tar.xz"
SRC_URI[sha256sum] = "08b17149f7dc41bceb325a0d5b924c6f7ba15d3d95d959d9a4a4a3957824e45c"

