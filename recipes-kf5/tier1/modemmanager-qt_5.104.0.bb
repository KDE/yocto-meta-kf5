# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/modemmanager-qt-5.104.0.tar.xz"
SRC_URI[sha256sum] = "7bfe8cd8925d36476772f0dc2347dda8da705c804b53c581bef610696e992b6d"

