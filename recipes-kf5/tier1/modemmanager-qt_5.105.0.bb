# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/modemmanager-qt-5.105.0.tar.xz"
SRC_URI[sha256sum] = "5cb26fad66b70216c5e3d406e98769d0c90704c1d9a36b2bceac6d0a6efe5ce4"

