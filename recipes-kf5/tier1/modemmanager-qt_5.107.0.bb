# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/modemmanager-qt-5.107.0.tar.xz"
SRC_URI[sha256sum] = "c1df6ec05e104a80c340fb4e4317725931a69bb48b8fb2666e5804cc09d6c439"

