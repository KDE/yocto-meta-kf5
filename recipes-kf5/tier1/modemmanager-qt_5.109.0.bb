# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/modemmanager-qt-${PV}.tar.xz"
SRC_URI[sha256sum] = "f2974e528e046c35fe11c6401e980eb73203734814633f541f016572e8ad56a8"

