# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/modemmanager-qt-5.110.0.tar.xz"
SRC_URI[sha256sum] = "3b9c2a548b3032a180088b59f93955f415ea19b1ec7f0639ce01e1d4b31a0423"

