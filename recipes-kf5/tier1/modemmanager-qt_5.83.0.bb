# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/modemmanager-qt-5.83.0.tar.xz"
SRC_URI[sha256sum] = "5e66e27bcf8f8f1fcaf634f89cc163a2dfa9346ccd92fe630d08a97653bf773d"

