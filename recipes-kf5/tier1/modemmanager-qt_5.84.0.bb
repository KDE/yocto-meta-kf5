# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/modemmanager-qt-5.84.0.tar.xz"
SRC_URI[sha256sum] = "36f6341c4c9fa8dcd87484e75339b1b12dad31ef6b97733ccce1ad3ff05b0dcc"

