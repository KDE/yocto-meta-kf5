# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/modemmanager-qt-5.85.0.tar.xz"
SRC_URI[sha256sum] = "52d82f24f41564436efa8829b36616bc77209c0e6e253ebcf0d9b0668c3862c9"

