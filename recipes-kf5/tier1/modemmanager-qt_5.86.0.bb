# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/modemmanager-qt-5.86.0.tar.xz"
SRC_URI[sha256sum] = "a34ec0f65280437842dc3b391045412df7ab2f69eb70c5d03772bb9cf8e8ab5d"

