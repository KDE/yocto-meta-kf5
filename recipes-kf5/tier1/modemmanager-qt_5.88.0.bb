# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/modemmanager-qt-5.88.0.tar.xz"
SRC_URI[sha256sum] = "f4e630d15e2eb524e89d73a51d9d73467f946bae42aaae8dd20a46e36f8c9bbc"

