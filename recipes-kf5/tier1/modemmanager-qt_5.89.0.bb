# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/modemmanager-qt-5.89.0.tar.xz"
SRC_URI[sha256sum] = "d10550ac6a1db03d0d9151f5e4143fdef8d66eae0f3660ae7f09a261324355e9"

