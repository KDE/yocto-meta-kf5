# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/modemmanager-qt-5.90.0.tar.xz"
SRC_URI[sha256sum] = "09987b2625de29626de27c30e4b589f3962596b80f1114afce836e4ecbdbd422"

