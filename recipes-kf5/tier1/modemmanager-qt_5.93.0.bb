# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/modemmanager-qt-5.93.0.tar.xz"
SRC_URI[sha256sum] = "3aedde6936524b9d0dea07ead34f44fcff50da2ccc0da73d6208893e270a67a8"

