# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/modemmanager-qt-5.94.0.tar.xz"
SRC_URI[sha256sum] = "7928dc36bad38a9721305d59bb6d318e35118843001c21aa8802ce11ce11bff2"

