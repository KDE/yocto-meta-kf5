# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/modemmanager-qt-5.96.0.tar.xz"
SRC_URI[sha256sum] = "0dd6f0e3ee3aa4ddc974e376b3fd1e3ebebdb6e1377dea8e67480ca903c471e5"

