# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/modemmanager-qt-5.97.0.tar.xz"
SRC_URI[sha256sum] = "938001d0d28c9d51cbc8fcdf45aefb2028c227e33037f98fb89ed6214936e561"

