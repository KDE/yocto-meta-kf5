# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/modemmanager-qt-5.98.0.tar.xz"
SRC_URI[sha256sum] = "73049850238a0d528f3db7d38609e3ca51622335df42a99a50a190908797643e"

