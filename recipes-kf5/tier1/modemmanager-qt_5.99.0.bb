# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/modemmanager-qt-5.99.0.tar.xz"
SRC_URI[sha256sum] = "ef841ce5f0e7d77cfa305a1bc32af40b08319118823a33199e0577f5a6cd4c72"

