# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/networkmanager-qt-5.101.0.tar.xz"
SRC_URI[sha256sum] = "1ac9f45452399bda18f1c17b8e1305463cf41738f3f94348614c81875f22eb76"

