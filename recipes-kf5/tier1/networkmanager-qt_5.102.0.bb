# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/networkmanager-qt-5.102.0.tar.xz"
SRC_URI[sha256sum] = "c9dc8b0df20c986527f53fe9d10525f94135b3de082dbf88eadeb778e174078b"

