# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/networkmanager-qt-5.103.0.tar.xz"
SRC_URI[sha256sum] = "1dcae357098af4ce31e25f80ee2e0c4e26080a5abb1286916fdf915231b021ce"

