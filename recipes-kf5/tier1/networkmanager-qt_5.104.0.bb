# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/networkmanager-qt-5.104.0.tar.xz"
SRC_URI[sha256sum] = "0a2bd7cfebf574ce70865fc83e7dddfcfe20617df858c76ad556402fe2a1c388"

