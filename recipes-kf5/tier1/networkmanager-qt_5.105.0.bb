# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/networkmanager-qt-5.105.0.tar.xz"
SRC_URI[sha256sum] = "bdf74d4a3d945837696e639742cbdc8aefdea03c4ceb9b2fed4cf74685ca14c3"

