# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/networkmanager-qt-5.107.0.tar.xz"
SRC_URI[sha256sum] = "695ffd3ef62023389f99363622320dc4af61e6d3e5606d006fbc5864f0d3197f"

