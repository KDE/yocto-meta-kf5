# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/networkmanager-qt-${PV}.tar.xz"
SRC_URI[sha256sum] = "7f415d77382fc7c8b459faaca6d588b0a478f47655aa0781dcc818416bd9fe3d"

