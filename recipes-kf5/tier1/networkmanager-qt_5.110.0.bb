# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/networkmanager-qt-5.110.0.tar.xz"
SRC_URI[sha256sum] = "1837f9b4795124f7fb0e63d75ea8f29b575e5a9f3ff5ae5e26861a0eddddd4ae"

