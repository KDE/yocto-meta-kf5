# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/networkmanager-qt-5.83.0.tar.xz"
SRC_URI[sha256sum] = "618fd7e68438dce44b287a3b46c790853604f65017b84fcebbf4eb31b443686d"

