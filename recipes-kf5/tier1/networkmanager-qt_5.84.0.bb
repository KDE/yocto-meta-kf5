# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/networkmanager-qt-5.84.0.tar.xz"
SRC_URI[sha256sum] = "e740c5774758cd86188c2584bb5dbaefe0777cae536bd3b6fc360709c545a5e1"

