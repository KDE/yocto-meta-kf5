# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/networkmanager-qt-5.85.0.tar.xz"
SRC_URI[sha256sum] = "d940bbe19c1b09fa9ed2c5e55dbd8bdd080ffdf7803603bb96c4d634573ce1d1"

