# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/networkmanager-qt-5.86.0.tar.xz"
SRC_URI[sha256sum] = "5bdcabf2dbf476c3f1253097efa4ac37274b7aa2e68545fb0f630c66db733fc0"

