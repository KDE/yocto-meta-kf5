# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/networkmanager-qt-5.88.0.tar.xz"
SRC_URI[sha256sum] = "8690c8922896e29a2b8c48a3312801bd25a164c0d5bb79f2ab0fc16eb2cf5281"

