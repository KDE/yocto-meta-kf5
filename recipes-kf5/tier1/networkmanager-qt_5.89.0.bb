# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/networkmanager-qt-5.89.0.tar.xz"
SRC_URI[sha256sum] = "045fd1fa88c6d187f75569bb145240d6da92a47839f96ae40210d5469cee37f4"

