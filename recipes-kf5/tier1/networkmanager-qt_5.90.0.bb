# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/networkmanager-qt-5.90.0.tar.xz"
SRC_URI[sha256sum] = "4769cf118cada3a3adb815da976ecb1aaf466d6504c7667f1034aeb97ade3c45"

