# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/networkmanager-qt-5.93.0.tar.xz"
SRC_URI[sha256sum] = "b8588ce2d811094682f51ea6150f3c58baa398fc91339bcb511bf60bc0eba960"

