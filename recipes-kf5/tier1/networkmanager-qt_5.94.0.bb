# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/networkmanager-qt-5.94.0.tar.xz"
SRC_URI[sha256sum] = "12208cc319ff0e77bbc1c37437e0fde57f62aa2a4d0f9e26110e8eb27b986502"

