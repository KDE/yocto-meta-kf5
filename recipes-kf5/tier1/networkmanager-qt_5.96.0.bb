# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/networkmanager-qt-5.96.0.tar.xz"
SRC_URI[sha256sum] = "dffd2c9df0121003ee8059b1aff657b58bf12dde4fc2b9d2d30a00ca817fdbbf"

