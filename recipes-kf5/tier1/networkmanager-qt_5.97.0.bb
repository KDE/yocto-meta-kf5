# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/networkmanager-qt-5.97.0.tar.xz"
SRC_URI[sha256sum] = "8556ad0ee255ce2947aad623db90848f7cfb0034368b0193f86af40499fa6c81"

