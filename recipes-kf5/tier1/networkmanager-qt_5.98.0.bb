# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/networkmanager-qt-5.98.0.tar.xz"
SRC_URI[sha256sum] = "bcc5b47b16c0e5e3f3c58e6596eeff76a175f7f7ea1d5ec1a0dea299b6003068"

