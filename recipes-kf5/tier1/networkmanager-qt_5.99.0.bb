# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/networkmanager-qt-5.99.0.tar.xz"
SRC_URI[sha256sum] = "49d98f97d7fcc1bccbdae43d23b061edb0040ba4a309dd605e2a4b26476f8318"

