# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/oxygen-icons5-5.101.0.tar.xz"
SRC_URI[sha256sum] = "741a9b8cedf5e963ef4c7ce7dcc5c6b8ceb86a91828e19c9bcb730c44a82412f"

