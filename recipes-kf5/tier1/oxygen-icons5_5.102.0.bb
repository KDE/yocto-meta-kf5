# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/oxygen-icons5-5.102.0.tar.xz"
SRC_URI[sha256sum] = "c4d553c3bf874b80983da8f1eb510fb113f0c6630501fd50ddc3ab36a88cbc16"

