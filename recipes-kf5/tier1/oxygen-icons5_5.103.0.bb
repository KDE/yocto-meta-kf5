# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/oxygen-icons5-5.103.0.tar.xz"
SRC_URI[sha256sum] = "387fbe84d111eb7aae0ba922a05cabfd87decb81c951dec8a20ae7c9d487968c"

