# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/oxygen-icons5-5.104.0.tar.xz"
SRC_URI[sha256sum] = "055f1e89b388b13f79af8773e66884a6eca33e41fcf01f1c274be4d336a9c6e8"

