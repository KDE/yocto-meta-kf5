# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/oxygen-icons5-5.105.0.tar.xz"
SRC_URI[sha256sum] = "82568b106969f4b1e79f24b97a201ddcb82f59fce685a16d56e1fbf97ac13b49"

