# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/oxygen-icons5-5.107.0.tar.xz"
SRC_URI[sha256sum] = "3afd9a59b37dd558f45a92db64783adc49b2fab01c6f68f2bf9f0a8367a7cfd0"

