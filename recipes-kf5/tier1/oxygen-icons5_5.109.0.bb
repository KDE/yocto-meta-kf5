# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/oxygen-icons5-${PV}.tar.xz"
SRC_URI[sha256sum] = "2bdfb4c16445f2cd83dae4e35cf06eaf5be26d3c1f0d238f7d0fdbfe3675c609"

