# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/oxygen-icons5-5.110.0.tar.xz"
SRC_URI[sha256sum] = "42c56983b59c0bf66ea489f7b8dd95eb15ca2d0945ce94d6f580ae870a79b1b6"

