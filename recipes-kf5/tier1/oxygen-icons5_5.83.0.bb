# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/oxygen-icons5-5.83.0.tar.xz"
SRC_URI[sha256sum] = "1789ad130213100745e2c8c27dd1d956d5d9b2b96f0f7f71b452a9cad746e610"

