# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/oxygen-icons5-5.84.0.tar.xz"
SRC_URI[sha256sum] = "5490b90f39a7bd098380969ee89b3b3dc8f3c2f8b1ecb722a381e8bda960011a"

