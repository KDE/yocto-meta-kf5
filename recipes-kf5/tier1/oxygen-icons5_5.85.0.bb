# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/oxygen-icons5-5.85.0.tar.xz"
SRC_URI[sha256sum] = "cf107c6f94c97363356b18938f537ee1059ff0909557ba7d847dcf5aac19c145"

