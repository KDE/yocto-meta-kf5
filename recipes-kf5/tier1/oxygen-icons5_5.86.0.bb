# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/oxygen-icons5-5.86.0.tar.xz"
SRC_URI[sha256sum] = "a2acd0ae5fde26f4d9ac32c0e18ec48f99b881e91e35adfc75a0b01ab8e1f6d1"

