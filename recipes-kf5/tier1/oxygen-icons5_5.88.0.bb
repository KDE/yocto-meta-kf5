# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/oxygen-icons5-5.88.0.tar.xz"
SRC_URI[sha256sum] = "b7e36ea83cf840dbbc7a0a9fe0528b64d96c764e0485ed5d6e0c5cbb3072f12f"

