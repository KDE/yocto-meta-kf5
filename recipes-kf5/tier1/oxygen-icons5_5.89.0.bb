# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/oxygen-icons5-5.89.0.tar.xz"
SRC_URI[sha256sum] = "f966276ad223f330ceb765a99d07b5482710353b5b272faea240390ccb14bdbe"

