# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/oxygen-icons5-5.90.0.tar.xz"
SRC_URI[sha256sum] = "2f747c4daf561306b25c347cb3a716bec32093ab8bd3e3ab8fbceed89981eec7"

