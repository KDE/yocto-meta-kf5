# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/oxygen-icons5-5.93.0.tar.xz"
SRC_URI[sha256sum] = "734e3f44dc3be665350ac5de7f333ab954d3e3b777765b691603b3647c353005"

