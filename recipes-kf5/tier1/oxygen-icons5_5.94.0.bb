# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/oxygen-icons5-5.94.0.tar.xz"
SRC_URI[sha256sum] = "203d9dbc3fb783c8c31c3d3d59624e31b502a50beea31505dcc56d8c33fcd1d0"

