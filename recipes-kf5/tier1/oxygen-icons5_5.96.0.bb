# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/oxygen-icons5-5.96.0.tar.xz"
SRC_URI[sha256sum] = "0557a74daac4ad59bfd80626593aed2f91e3bd12782367f458cfc792bf916eb8"

