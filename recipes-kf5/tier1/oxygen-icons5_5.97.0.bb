# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/oxygen-icons5-5.97.0.tar.xz"
SRC_URI[sha256sum] = "554b6df8204654aee941f378c941277f81998522c6c67659625f16200225f9fa"

