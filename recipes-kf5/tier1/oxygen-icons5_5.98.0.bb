# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/oxygen-icons5-5.98.0.tar.xz"
SRC_URI[sha256sum] = "782d7e72e193baf1d66f6cc8fc71cec4b66af3c1d19365c7c940be8ca128930f"

