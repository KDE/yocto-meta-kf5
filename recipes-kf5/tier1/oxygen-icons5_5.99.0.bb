# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/oxygen-icons5-5.99.0.tar.xz"
SRC_URI[sha256sum] = "8ce6ab8a0158f6e3673961fe6a37830af11d776f722f968d66dc257d5b0253dd"

