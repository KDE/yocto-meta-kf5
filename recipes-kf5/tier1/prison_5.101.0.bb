# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/prison-5.101.0.tar.xz"
SRC_URI[sha256sum] = "b54fcf84d18f24562e74e0bfa252a51ff09dd0a1ab81f5919053e4e868b5cdf6"

