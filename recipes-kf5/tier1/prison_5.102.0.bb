# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/prison-5.102.0.tar.xz"
SRC_URI[sha256sum] = "d626312893e07cb3ab47e535cf2959e87ccd622f6e1e991d46570907892681c7"

