# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/prison-5.103.0.tar.xz"
SRC_URI[sha256sum] = "44c5f902fac041e6aeb2baa6f26a1b58b3531d500f40e0411e171d3607b0f288"

