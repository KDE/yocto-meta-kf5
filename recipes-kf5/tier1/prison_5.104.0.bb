# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/prison-5.104.0.tar.xz"
SRC_URI[sha256sum] = "2c81ac3bfbaa3baaad532508a8e09a903c2878da29af9bfa0e9c873b0681f6b8"

