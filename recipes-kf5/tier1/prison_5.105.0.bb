# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/prison-5.105.0.tar.xz"
SRC_URI[sha256sum] = "6e05ec6085df7a33e74e450286f596fe7368bbec6ef46e67efd1738966784261"

