# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/prison-5.107.0.tar.xz"
SRC_URI[sha256sum] = "cc702edf7fd3f36b567ca2d1bfc315e80312e7e33fb6a0db49cc4a3b6fa64a9c"

