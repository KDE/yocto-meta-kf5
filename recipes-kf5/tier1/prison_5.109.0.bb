# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/prison-${PV}.tar.xz"
SRC_URI[sha256sum] = "8109d7daada25735e4aa9c0f0b51640f34386aa51a9d03bb49b84a0359e8bcde"

