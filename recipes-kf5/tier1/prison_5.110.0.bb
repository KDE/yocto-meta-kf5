# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/prison-5.110.0.tar.xz"
SRC_URI[sha256sum] = "677170740a5cd8c80917b301f3e874fef7e8ca1aad1507d558f6e087c21f2a05"

