# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/prison-5.83.0.tar.xz"
SRC_URI[sha256sum] = "6af9ecd86b07a055a16ba96dd01b69c5304f91307cdcc7c9b063fda5d561e2c8"

