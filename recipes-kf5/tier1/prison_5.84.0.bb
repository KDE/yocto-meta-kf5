# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/prison-5.84.0.tar.xz"
SRC_URI[sha256sum] = "f27a51658a0fa3f761cb231542c92931f34e5a7030f7d8792b12a18b1d206d9d"

