# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/prison-5.85.0.tar.xz"
SRC_URI[sha256sum] = "5694331eede92a4d6c601c83b61b56266ded86453d1abd794fdad84131c1cdb0"

