# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/prison-5.86.0.tar.xz"
SRC_URI[sha256sum] = "2252f6c4778bfbe85eba0cbe3b18f66e1c879b40ea73cf5db87f34c4d5e851dc"

