# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/prison-5.88.0.tar.xz"
SRC_URI[sha256sum] = "37a16df7ac823f7e97a7e1e9ef48a794879bf81cccb126809b24e25091343f7a"

