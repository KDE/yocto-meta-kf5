# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/prison-5.89.0.tar.xz"
SRC_URI[sha256sum] = "64a46cc9e4447b9b98f7c53e80d9bd78a668770d285f39d7c5dd9159a4c3a349"

