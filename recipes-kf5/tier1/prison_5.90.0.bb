# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/prison-5.90.0.tar.xz"
SRC_URI[sha256sum] = "d36fa8550af7265e56af3ab9d10465f73aeae0ce18b5877351db20293d14537c"

