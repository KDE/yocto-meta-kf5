# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/prison-5.93.0.tar.xz"
SRC_URI[sha256sum] = "1f43de6622cf263c6b71f9a801174e2791c09b5a0d52c602715659ddfb82fb56"

