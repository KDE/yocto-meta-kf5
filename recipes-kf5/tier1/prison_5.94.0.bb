# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/prison-5.94.0.tar.xz"
SRC_URI[sha256sum] = "99607978559f63dba65d796c5edaf6c54e8aee5d31882d856347ea5ada06d1cb"

