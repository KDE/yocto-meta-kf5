# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/prison-5.96.0.tar.xz"
SRC_URI[sha256sum] = "ba2785b054e36950a4561786bcff9fdb80bcc5a0122d1cee403326e95746f4cf"

