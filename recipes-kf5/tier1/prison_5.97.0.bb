# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/prison-5.97.0.tar.xz"
SRC_URI[sha256sum] = "a6f04ff1b9823c43881da38091a87970dba6d79a0f3a8103146fc2b03aaf531b"

