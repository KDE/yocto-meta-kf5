# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/prison-5.98.0.tar.xz"
SRC_URI[sha256sum] = "dc307532430a5463f95d7bbf8e03a4bb5e3b4650c9fecd6c600e61035ca8f8de"

