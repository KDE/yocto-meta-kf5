# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/prison-5.99.0.tar.xz"
SRC_URI[sha256sum] = "84deb9c19e79ca73fee27151e140006f4eebd5326bc22a226a2b7bfbf074c1f1"

