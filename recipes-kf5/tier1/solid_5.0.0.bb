require ${PN}.inc

SRC_URI = "${GIT_REPO}"
# 5 commits past 5.0.0, due to licensing
SRCREV = "d89d25980ac1b4c5ee51058ea746984aec23c1e1" 
PV = "5.0.0"
