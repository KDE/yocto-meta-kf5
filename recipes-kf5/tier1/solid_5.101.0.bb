# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/solid-5.101.0.tar.xz"
SRC_URI[sha256sum] = "7057825d5de721858af9be698a7114cd45e33bee7c06006a8ec68c05bf141a7a"

