# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/solid-5.102.0.tar.xz"
SRC_URI[sha256sum] = "06e3d3cc7400529bb5ec05f16a4b711a72104aaa44ce1a4bc3d00e9d589ab132"

