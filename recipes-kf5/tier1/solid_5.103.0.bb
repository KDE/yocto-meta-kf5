# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/solid-5.103.0.tar.xz"
SRC_URI[sha256sum] = "e067087bcfc9d18dd2bfdf7b33901ee20fcdf7ba907242adc53356fd44e3d344"

