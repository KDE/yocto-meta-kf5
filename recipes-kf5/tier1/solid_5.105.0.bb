# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/solid-5.105.0.tar.xz"
SRC_URI[sha256sum] = "fdcd5c0ee1060204f46ff88a0ab25403b6d83676d0d9f407209ce3bc6629aab5"

