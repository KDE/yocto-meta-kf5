# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/solid-${PV}.tar.xz"
SRC_URI[sha256sum] = "bc4dfb6d1792711a48745ddb3698ed764da86fca1f79a1b931072e910b4bd569"

