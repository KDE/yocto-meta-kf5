# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/solid-5.110.0.tar.xz"
SRC_URI[sha256sum] = "6db3e60bc1d579bcce2d3eeb38f8edba5bb7d549e17116449cdd1ecd2966c4cc"

