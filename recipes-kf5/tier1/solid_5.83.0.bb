# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/solid-5.83.0.tar.xz"
SRC_URI[sha256sum] = "73b5a653112122f2c874118d9e56b246e93fb9a715cc3706e2aa77e15ea458c6"

