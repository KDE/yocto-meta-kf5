# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/solid-5.86.0.tar.xz"
SRC_URI[sha256sum] = "a0862c0c78102705be5f36b2b45e2e2ceb0d7e443dc3251dbd7baf03f3218b6d"

