# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/solid-5.88.0.tar.xz"
SRC_URI[sha256sum] = "cf850337434f6844750bda625fb769615202cda0c047b4bc9dbc44634f556fea"

