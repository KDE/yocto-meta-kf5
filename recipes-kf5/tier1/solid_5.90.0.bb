# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/solid-5.90.0.tar.xz"
SRC_URI[sha256sum] = "3782bee19dff9e24e60782a8a2f297b1049bd50eaac3a2e389b0194160251382"

