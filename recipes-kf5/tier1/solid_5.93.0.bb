# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/solid-5.93.0.tar.xz"
SRC_URI[sha256sum] = "22eff3f94608793fecb532e097d9022a14c828a0ffad0f73666088153f0d6bea"

