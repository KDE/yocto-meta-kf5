# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/solid-5.94.0.tar.xz"
SRC_URI[sha256sum] = "9d8ed401e36b6a4b9e51438c8e2d359129b9d6149deb8240cb894b1128fa1107"

