# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/solid-5.96.0.tar.xz"
SRC_URI[sha256sum] = "9104542fec59bbfbd2b493d990a04849347d5ce10948a5bdf0bc9e17187dc448"

