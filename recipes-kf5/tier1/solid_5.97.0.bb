# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/solid-5.97.0.tar.xz"
SRC_URI[sha256sum] = "84c0ad4678c2ef6563db8a1dd907a8b9c4a2e8db7afc691a24b27189d6a24c9d"

