# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/solid-5.98.0.tar.xz"
SRC_URI[sha256sum] = "066427b9b2504a4e6bbc26994f1c9d4885aaef794c7bff6a861e4e0dc8146e91"

