# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/sonnet-5.101.0.tar.xz"
SRC_URI[sha256sum] = "6b03178b279ceed9a46742e87537fa23a43e3c471b7a73908564c20d42788ed0"

