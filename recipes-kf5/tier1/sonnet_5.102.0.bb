# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/sonnet-5.102.0.tar.xz"
SRC_URI[sha256sum] = "0eaa21b763fcf6607fa1db1789115484fcd58e993a0dfb1cd2638f0d288aac11"

