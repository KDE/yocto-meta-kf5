# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/sonnet-5.103.0.tar.xz"
SRC_URI[sha256sum] = "93382f20684064ab93803e02af303373b27786d871adeeb7da1e62c762c13e4f"

