# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/sonnet-5.104.0.tar.xz"
SRC_URI[sha256sum] = "17276e51f0f4ac2f8745796db135d3143f2f91ee3fc8fb823c94072de5c0b953"

