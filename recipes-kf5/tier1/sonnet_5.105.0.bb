# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/sonnet-5.105.0.tar.xz"
SRC_URI[sha256sum] = "28ef6a2da7f2321975d902e123c616811e1c19ef7bddd8550c1ac7294900e08f"

