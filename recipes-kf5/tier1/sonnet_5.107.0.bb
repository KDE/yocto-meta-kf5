# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/sonnet-5.107.0.tar.xz"
SRC_URI[sha256sum] = "aa3dca0a1cf58ae7914b75f67bb4a42202ba2ee4c5bf9df594a431da2496a747"

