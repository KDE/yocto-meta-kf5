# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/sonnet-5.110.0.tar.xz"
SRC_URI[sha256sum] = "1114a1fe84f390fbadd03cf434c1f741b75a4ffe18014633f903f8e0fd30139b"

