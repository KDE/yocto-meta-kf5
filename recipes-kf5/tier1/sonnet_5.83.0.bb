# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/sonnet-5.83.0.tar.xz"
SRC_URI[sha256sum] = "aad844fcfa4c9acb1a634528f35c56ec906e8a71c07f40dd1a748ac51e96502f"

