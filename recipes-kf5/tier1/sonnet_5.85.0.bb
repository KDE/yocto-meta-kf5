# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/sonnet-5.85.0.tar.xz"
SRC_URI[sha256sum] = "fce206399ca3b8d727d17ee00e6cd8139dc85650431e4cab3f932ec01270e2b1"

