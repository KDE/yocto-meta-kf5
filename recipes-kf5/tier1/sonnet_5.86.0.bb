# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/sonnet-5.86.0.tar.xz"
SRC_URI[sha256sum] = "12fcb1bab11cde11b14eb20a415bc5112170f68e90ca05a36885b8b05a16a367"

