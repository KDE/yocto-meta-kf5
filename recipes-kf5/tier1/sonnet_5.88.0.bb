# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/sonnet-5.88.0.tar.xz"
SRC_URI[sha256sum] = "8f99640923b500affd549c4990a9a5ee526b704bfab446e41588963ecade0869"

