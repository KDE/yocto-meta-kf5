# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/sonnet-5.89.0.tar.xz"
SRC_URI[sha256sum] = "41f5a87a5fecd6870420cd8a564fc5e074b64332002fe71dc0ae5c0f91e9b339"

