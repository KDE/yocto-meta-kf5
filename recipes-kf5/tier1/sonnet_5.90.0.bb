# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/sonnet-5.90.0.tar.xz"
SRC_URI[sha256sum] = "c7a772aec93c00fcd714b93b0596d2e918cb60f4e0937d7d152c07be53ed9d34"

