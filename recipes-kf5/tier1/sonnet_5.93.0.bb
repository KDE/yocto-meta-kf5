# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/sonnet-5.93.0.tar.xz"
SRC_URI[sha256sum] = "3c146ba45edee43bf2e8bc48b116a38e0c28d2294fe61b44dc8254b881210d9c"

