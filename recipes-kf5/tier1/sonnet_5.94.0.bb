# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/sonnet-5.94.0.tar.xz"
SRC_URI[sha256sum] = "8c570a64748d6bb6b91dff6fbf5e0cc5da7634c9a6f867944e99442066b7474c"

