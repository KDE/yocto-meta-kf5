# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/sonnet-5.96.0.tar.xz"
SRC_URI[sha256sum] = "046a20e5070b108cc515645bf9121cd5ed6515a6f3e5879783887a379b9e0f44"

