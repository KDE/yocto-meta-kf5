# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/sonnet-5.97.0.tar.xz"
SRC_URI[sha256sum] = "a392739767e7f56cc3d951f0e55f1fa1d36a9f48e1b601b825212b50a1941193"

