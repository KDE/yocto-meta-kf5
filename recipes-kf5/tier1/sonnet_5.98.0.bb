# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/sonnet-5.98.0.tar.xz"
SRC_URI[sha256sum] = "a3ae0141e11e2bb3fc0ace9b339d82b17ce9f83a751abcab1c8fe9d07b489748"

