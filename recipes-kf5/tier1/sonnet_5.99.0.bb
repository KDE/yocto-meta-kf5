# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/sonnet-5.99.0.tar.xz"
SRC_URI[sha256sum] = "f3f18e00f9205cfcf7d6923ccdbec480001da86f39623fe012773ee63afca7e4"

