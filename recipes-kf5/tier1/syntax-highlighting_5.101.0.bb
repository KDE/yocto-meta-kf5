# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/syntax-highlighting-5.101.0.tar.xz"
SRC_URI[sha256sum] = "31cddb233f79ce596f81bf66f4526a9b8ddb06e3224f200596e56bb0dc1f1d3b"

