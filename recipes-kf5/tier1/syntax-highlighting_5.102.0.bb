# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/syntax-highlighting-5.102.0.tar.xz"
SRC_URI[sha256sum] = "2f2724e44d9f9bca29d939e34ba2987d1703b133e82e0fffc0ced8e45171f20f"

