# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/syntax-highlighting-5.103.0.tar.xz"
SRC_URI[sha256sum] = "49198fad25183f8307ec8817f1de6444d5c00d690b210f8b5ce8c408009b3620"

