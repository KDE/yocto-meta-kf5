# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/syntax-highlighting-5.104.0.tar.xz"
SRC_URI[sha256sum] = "028d08849f04db91d8030a131fe72e0c50afd07f9ef7c3df331c979b6395cd45"

