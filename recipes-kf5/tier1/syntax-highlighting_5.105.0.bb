# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/syntax-highlighting-5.105.0.tar.xz"
SRC_URI[sha256sum] = "f558b8203359911fef33701e9bebbfaa7eb7cddcd34440d4d886fb5709d0114c"

