# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/syntax-highlighting-5.107.0.tar.xz"
SRC_URI[sha256sum] = "672ed1e9eebbf13d012f027e729b1b9820c351d4a4b2ca57ffd0be4a71ac59d9"

