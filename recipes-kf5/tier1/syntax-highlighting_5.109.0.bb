# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/syntax-highlighting-${PV}.tar.xz"
SRC_URI[sha256sum] = "9e637ae8e92dce33ab0f658e30d6aa132fc354304f90ffb099cd27c776d0b5c7"

