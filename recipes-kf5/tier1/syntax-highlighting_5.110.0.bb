# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/syntax-highlighting-5.110.0.tar.xz"
SRC_URI[sha256sum] = "85277cab858cd04f3b4861daf5d885706e0e9da3e081e098849d7806ac7a753d"

