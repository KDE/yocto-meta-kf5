# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/syntax-highlighting-5.83.0.tar.xz"
SRC_URI[sha256sum] = "553084ecd116cadbf2a75725a33857df7d15b92124ac79f870a5f7ba6e5c9e5e"

