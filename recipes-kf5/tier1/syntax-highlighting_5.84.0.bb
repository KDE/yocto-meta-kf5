# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/syntax-highlighting-5.84.0.tar.xz"
SRC_URI[sha256sum] = "aafb3a7be2438ce6e229674f134a739f57ae0a26e98f628f33ae6731536c64d5"

