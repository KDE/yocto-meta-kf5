# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/syntax-highlighting-5.86.0.tar.xz"
SRC_URI[sha256sum] = "e300a5eb56c57b7a576059337c29aba7191c4971a4b9f5c739e211b83791010d"

