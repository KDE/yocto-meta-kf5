# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/syntax-highlighting-5.90.0.tar.xz"
SRC_URI[sha256sum] = "bf483e79c731a88ef642c9551ee092c4201d926af5b172bc11b1acde5c9baca6"

