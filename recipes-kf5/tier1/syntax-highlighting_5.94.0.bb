# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/syntax-highlighting-5.94.0.tar.xz"
SRC_URI[sha256sum] = "cf871332a50355836919fdd833a82c32b3d5fe7fea8fa3e58714c39c8ddde5a6"

