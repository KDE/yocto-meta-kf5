# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/syntax-highlighting-5.96.0.tar.xz"
SRC_URI[sha256sum] = "1affa16519f04e0a05f37fda67acce2ac943e74eb8322591896765d7e1cbd79c"

