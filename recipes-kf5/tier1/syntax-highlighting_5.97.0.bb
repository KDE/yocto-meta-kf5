# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/syntax-highlighting-5.97.0.tar.xz"
SRC_URI[sha256sum] = "e88b9691ffead9cbfb11ae43c497114c7695e1e455e78dad30743c90ab50a99d"

