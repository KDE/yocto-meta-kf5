# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/syntax-highlighting-5.98.0.tar.xz"
SRC_URI[sha256sum] = "02c7a76cb8c21cf279084052f4bff278ff76959e3df0c4e8c2aa230de1a25124"

