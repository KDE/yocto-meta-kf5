require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "cfbea9ea8e4988b1762f7b9b824c2328b3f233b7"
PV = "5.0.0"
