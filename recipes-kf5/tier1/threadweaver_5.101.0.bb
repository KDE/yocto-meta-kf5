# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/threadweaver-5.101.0.tar.xz"
SRC_URI[sha256sum] = "4fd103c528590fa974f267d6de5a709b942cee15247b3d877f27d997ff62fbfb"

