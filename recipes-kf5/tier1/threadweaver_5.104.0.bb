# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/threadweaver-5.104.0.tar.xz"
SRC_URI[sha256sum] = "963decfdf0cf780406eb585efdb213539a00cd16ae4dff2b2ffe8822a609a647"

