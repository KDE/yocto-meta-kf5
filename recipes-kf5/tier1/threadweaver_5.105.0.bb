# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/threadweaver-5.105.0.tar.xz"
SRC_URI[sha256sum] = "97c64a0bbdcc40cf9e374342db5062b657a18dbcf097976d94c2eb31955186e1"

