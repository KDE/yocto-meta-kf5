# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/threadweaver-5.107.0.tar.xz"
SRC_URI[sha256sum] = "c6c4faaf3c2b2197d43fddae39d752c4ad32febee039eb8048f8d705c1393af2"

