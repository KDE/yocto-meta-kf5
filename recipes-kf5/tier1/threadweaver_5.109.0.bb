# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/threadweaver-${PV}.tar.xz"
SRC_URI[sha256sum] = "7274529540c4f478519271655a409e4d89c297683eab531a764cf2e5b8c2d2e0"

