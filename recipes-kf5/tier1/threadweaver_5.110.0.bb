# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/threadweaver-5.110.0.tar.xz"
SRC_URI[sha256sum] = "a0ea5936aafa0226648b89d8c12c25557ae42c975ad08fefd6cb67f04f25be20"

