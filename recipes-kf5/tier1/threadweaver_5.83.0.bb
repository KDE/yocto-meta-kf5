# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/threadweaver-5.83.0.tar.xz"
SRC_URI[sha256sum] = "540ecedea40f1dec1fdda76464a2a610de713b03cc86f06c7245f307a1b2098a"

