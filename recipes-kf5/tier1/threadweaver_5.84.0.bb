# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/threadweaver-5.84.0.tar.xz"
SRC_URI[sha256sum] = "e294e61d72dd0fc678c655475694fc1df3d703e04b043ae0a8666ed9399ebd42"

