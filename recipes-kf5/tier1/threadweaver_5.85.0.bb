# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/threadweaver-5.85.0.tar.xz"
SRC_URI[sha256sum] = "431b4a480d200bf12e88ce510efd56edb062eb2284d4233f9602ae62a75da555"

