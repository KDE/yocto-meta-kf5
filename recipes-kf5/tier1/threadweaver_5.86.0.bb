# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/threadweaver-5.86.0.tar.xz"
SRC_URI[sha256sum] = "84dcbe648e2960084b13ad59a88dd7ed7fee0305351b015345d59848072e64be"

