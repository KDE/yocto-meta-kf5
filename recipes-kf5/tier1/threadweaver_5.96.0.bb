# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/threadweaver-5.96.0.tar.xz"
SRC_URI[sha256sum] = "78b5cf0b8d5937ac998c3b6f73926bdd483688b758da800126ff0b56f9b25252"

