# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/threadweaver-5.97.0.tar.xz"
SRC_URI[sha256sum] = "46975d03feea09c41ac369fd076d7b2c92ad4468a81f48c2eeff622eabfc408f"

