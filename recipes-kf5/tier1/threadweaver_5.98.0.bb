# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/threadweaver-5.98.0.tar.xz"
SRC_URI[sha256sum] = "5acc0d34e83568a18444537e91eeef93986a8ec3c4b6c326319de959feb591df"

