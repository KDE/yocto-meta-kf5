# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kactivities-5.101.0.tar.xz"
SRC_URI[sha256sum] = "f708b04b35adcee7dbbb2a21327417ad2082e3dc610f8527c7875049a5f781ac"

