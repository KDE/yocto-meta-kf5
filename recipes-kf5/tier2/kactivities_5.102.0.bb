# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kactivities-5.102.0.tar.xz"
SRC_URI[sha256sum] = "f9795e6b4b0699c6db385b83f391d8a3bccf1b0794381de0f14f7da288a281ce"

