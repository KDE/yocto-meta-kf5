# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kactivities-5.103.0.tar.xz"
SRC_URI[sha256sum] = "6d328b968eae1b1b7d2582f7e3b721b4de5296af98796956dd52ce84ba4f8835"

