# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kactivities-5.104.0.tar.xz"
SRC_URI[sha256sum] = "29c31525763a44def441fed012af951fe424bd9a88892701ddf16d84f0917953"

