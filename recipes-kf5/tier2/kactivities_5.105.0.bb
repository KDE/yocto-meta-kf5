# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kactivities-5.105.0.tar.xz"
SRC_URI[sha256sum] = "8fd4033c288fd03953a39f43d7d3967024252d29265bc6803adfa9ac166cf0b2"

