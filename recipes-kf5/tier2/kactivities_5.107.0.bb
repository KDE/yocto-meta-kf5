# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kactivities-5.107.0.tar.xz"
SRC_URI[sha256sum] = "19b79539a72e5a8b13f7eb94789eb61a5d5945003a86aa121203017cf3139b29"

