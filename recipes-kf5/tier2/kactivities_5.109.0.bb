# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kactivities-${PV}.tar.xz"
SRC_URI[sha256sum] = "1c7eef71a887c612af89ec6813282a13dcc1a9b0762c59412a8ef8b5419a52f1"

