# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kactivities-5.110.0.tar.xz"
SRC_URI[sha256sum] = "4565f8216f8134b91d58a0697d5892e0c6675fbe6fd639a8a0ece8c1a42924b0"

