# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kactivities-5.83.0.tar.xz"
SRC_URI[sha256sum] = "dac6c92eea2731e835b8d15d54033ab86388371b1627fdc72ddbb7027639177b"

