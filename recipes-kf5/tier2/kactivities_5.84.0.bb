# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kactivities-5.84.0.tar.xz"
SRC_URI[sha256sum] = "86b0909d486c5b5fc849bbf6dbdfff9deaf2f5764d3633e681e2d52d53ee3052"

