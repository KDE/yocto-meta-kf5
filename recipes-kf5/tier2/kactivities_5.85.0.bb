# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kactivities-5.85.0.tar.xz"
SRC_URI[sha256sum] = "f5891d94176178e0dcfebbeb97e80ed0b63a09a5312523156319cdd16fcc8030"

