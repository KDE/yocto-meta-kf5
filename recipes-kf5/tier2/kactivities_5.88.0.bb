# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kactivities-5.88.0.tar.xz"
SRC_URI[sha256sum] = "ceec595cf5ff6de06a05fa54f0549a257e74afbfcc712b54a6018be7edb89822"

