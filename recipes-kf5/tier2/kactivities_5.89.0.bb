# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kactivities-5.89.0.tar.xz"
SRC_URI[sha256sum] = "69178cbfae079db504dc4fe5dd12d0964b92e66b10fec249bfd3107110a11db6"

