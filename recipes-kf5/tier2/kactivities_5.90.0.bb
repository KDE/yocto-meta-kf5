# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kactivities-5.90.0.tar.xz"
SRC_URI[sha256sum] = "bc8071efa15946e63a52fa40cdf4077a02108257de76cc058ee2cb359cb5c771"

