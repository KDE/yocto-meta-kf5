# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kactivities-5.93.0.tar.xz"
SRC_URI[sha256sum] = "eb6b204382d3bba1b32b5752a3e8382a5a7bbd8be4b95b774c68c501a2f16843"

