# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kactivities-5.94.0.tar.xz"
SRC_URI[sha256sum] = "52dd5eba3daeb2a9bbb3a1865b3219277b3ca6357c2870c3570dfac10f445adf"

