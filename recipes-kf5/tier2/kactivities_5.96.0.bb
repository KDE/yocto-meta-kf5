# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kactivities-5.96.0.tar.xz"
SRC_URI[sha256sum] = "53cf05c948acb4203042b24fa09719e279d30098976809a061198868f698263c"

