# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kactivities-5.97.0.tar.xz"
SRC_URI[sha256sum] = "d12dbb6e6ff62244eb090027a00f72a4816358b1a18d7b96df8371865a06cf37"

