# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kactivities-5.98.0.tar.xz"
SRC_URI[sha256sum] = "31b5a957192b02e10b10ee46f95b6dbf4d56f8720876415581b7a2153c42f958"

