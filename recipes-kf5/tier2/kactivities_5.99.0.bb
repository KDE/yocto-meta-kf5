# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kactivities-5.99.0.tar.xz"
SRC_URI[sha256sum] = "69e8859509564a5993241cd6e6b7480c344dfe7c691710705cd5316d87fcf2d0"

