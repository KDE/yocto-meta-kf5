require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "63abc315ec9bea4860e2600913d59e4c288cc418"
PV = "5.0.0"
