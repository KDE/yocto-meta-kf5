# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kauth-5.101.0.tar.xz"
SRC_URI[sha256sum] = "cee3b9fcc3b265abd8bbaa958ef87174bc3c02b5862c93c581bc55de26776d94"

