# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kauth-5.102.0.tar.xz"
SRC_URI[sha256sum] = "8d12065cecc033936df4238f7d6ccebf5753aced0d161cd444300ffe7e0e6c24"

