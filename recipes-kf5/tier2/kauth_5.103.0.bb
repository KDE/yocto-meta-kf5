# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kauth-5.103.0.tar.xz"
SRC_URI[sha256sum] = "cd39aea44deaa480e4c1e4a388eacb54293e8dca38e1034cdd5950edd3023d54"

