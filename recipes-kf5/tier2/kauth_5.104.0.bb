# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kauth-5.104.0.tar.xz"
SRC_URI[sha256sum] = "614086598e66c1f136e5a6296f358548509e0e868f62a03c97ade73d9b7d581e"

