# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kauth-5.105.0.tar.xz"
SRC_URI[sha256sum] = "1c660838a2ca9a226f180e0ab654fbb15eee2fc7140a7157e6a2209e9b6c2833"

