# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kauth-5.107.0.tar.xz"
SRC_URI[sha256sum] = "06bd7f9b3b9c57ff8f169ba09ee0c160aef8dceb651caa28d154448883db8fff"

