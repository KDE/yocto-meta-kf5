# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kauth-5.110.0.tar.xz"
SRC_URI[sha256sum] = "e1b357b36f5388ecd96430bb98780d8429d00cccca0a56fc6d3c3f0cb7afd5fb"

