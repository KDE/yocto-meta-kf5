# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kauth-5.84.0.tar.xz"
SRC_URI[sha256sum] = "04c88ff501a60258fb1432edc81f7fe25794df4379dcfb9d6d6f71c8b2b29ecb"

