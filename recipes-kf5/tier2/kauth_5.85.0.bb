# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kauth-5.85.0.tar.xz"
SRC_URI[sha256sum] = "1a3a93c475aa3191a7a2e1746a4d54a5b08d24e8f99a36816d6db67e2b8961c5"

