# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kauth-5.88.0.tar.xz"
SRC_URI[sha256sum] = "0539e6eb5c94da0309f2fbf1503444f2f8cc916ea8899ea05ce4170565d6f995"

