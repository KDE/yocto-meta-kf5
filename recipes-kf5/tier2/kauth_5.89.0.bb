# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kauth-5.89.0.tar.xz"
SRC_URI[sha256sum] = "df9a81af5b0754d528799ec944de02c1b22c4a4b97d9e3dc0132232d4fee49fb"

