# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kauth-5.90.0.tar.xz"
SRC_URI[sha256sum] = "23a45f68062432b65f4264f371e7f1753034dba3a86d5e44bf9fb1abf30d91bc"

