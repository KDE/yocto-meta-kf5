# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kauth-5.93.0.tar.xz"
SRC_URI[sha256sum] = "34580078bfdf631835f3ac52955f2149209908b935a7cfec6fe5b4956c3ada6c"

