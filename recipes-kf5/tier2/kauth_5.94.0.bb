# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kauth-5.94.0.tar.xz"
SRC_URI[sha256sum] = "9cfed0ad69a8fa5df88273a5ef340d7b6dff1cd3e9d53bda16f3cf4afdd64159"

