# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kauth-5.96.0.tar.xz"
SRC_URI[sha256sum] = "a9d7372aa8c984fe9693efcec1dba0daf76070c41301ca8d1120af45403123c2"

