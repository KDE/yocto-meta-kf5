# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kauth-5.97.0.tar.xz"
SRC_URI[sha256sum] = "d74dc553b3628657241d6e7129b17a38e5fd3b26b21de000390382c871ca42f5"

