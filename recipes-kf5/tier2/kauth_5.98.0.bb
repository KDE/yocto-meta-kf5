# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kauth-5.98.0.tar.xz"
SRC_URI[sha256sum] = "e6975e4d5f3e0218b1e75ec5bc71806c1b92a57389d2fb1f0bf8ae5845dfed5b"

