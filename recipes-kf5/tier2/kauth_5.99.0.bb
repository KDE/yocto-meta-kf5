# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kauth-5.99.0.tar.xz"
SRC_URI[sha256sum] = "36ba733733c8600b2b8ba7736dc78c3c4e817aa91c7bc91407b69d4be01bbf93"

