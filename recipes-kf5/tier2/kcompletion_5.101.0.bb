# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kcompletion-5.101.0.tar.xz"
SRC_URI[sha256sum] = "d80f6fbe23285f9f914ed67ffd2a825d36850c086121666bbb62257126553f30"

