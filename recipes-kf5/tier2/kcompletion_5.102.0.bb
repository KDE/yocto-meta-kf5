# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kcompletion-5.102.0.tar.xz"
SRC_URI[sha256sum] = "5b78ae92b18aa31c8055d2a0b01dd30ba466ccbd980d0a7f68890e24ac42f9c9"

