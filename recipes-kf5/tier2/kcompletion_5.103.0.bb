# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kcompletion-5.103.0.tar.xz"
SRC_URI[sha256sum] = "d02374cba2bb3da774a938ef72744282af80a6c63851baa5825af173c7cb764f"

