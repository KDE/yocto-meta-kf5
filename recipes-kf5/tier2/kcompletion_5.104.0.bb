# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kcompletion-5.104.0.tar.xz"
SRC_URI[sha256sum] = "b0ed0246871283df04c62f0df2b221e32911cb4d292d5ae42f860958032eb510"

