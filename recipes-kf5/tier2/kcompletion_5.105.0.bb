# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kcompletion-5.105.0.tar.xz"
SRC_URI[sha256sum] = "6e76e822a8b4e49d3357958fd3880858a59ccf4defd45a0e248c57535788b981"

