# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kcompletion-5.107.0.tar.xz"
SRC_URI[sha256sum] = "50ab6473d2092bf98fc6d0ed7000566e9bb490f1139e1a502dabc39dfe6449f5"

