# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kcompletion-${PV}.tar.xz"
SRC_URI[sha256sum] = "72c4a602664b88f16d138cd36a709afbee86a555609232084e29ddb0c2a4aaf1"

