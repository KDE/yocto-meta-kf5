# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kcompletion-5.110.0.tar.xz"
SRC_URI[sha256sum] = "4f04f1a41f4e49a15b06a60304d75f7945b506b12d65f03b27073c37d3353429"

