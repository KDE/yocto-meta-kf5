# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kcompletion-5.88.0.tar.xz"
SRC_URI[sha256sum] = "b64c7a2720675599385c0faedae27d5255694e6d6637455b2740d49d3a813938"

