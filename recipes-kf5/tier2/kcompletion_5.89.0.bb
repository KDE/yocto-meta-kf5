# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kcompletion-5.89.0.tar.xz"
SRC_URI[sha256sum] = "ee1be28f5c7312ef78ea6ddff62c0ff0e079c15313d7e4f49661e6db729f692f"

