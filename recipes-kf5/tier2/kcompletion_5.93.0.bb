# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kcompletion-5.93.0.tar.xz"
SRC_URI[sha256sum] = "7f8c9355e8875b619ca852741e972f41c252aa2e95b439161acc7b32d9e8fb9c"

