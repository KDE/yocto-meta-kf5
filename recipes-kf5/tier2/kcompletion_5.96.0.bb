# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kcompletion-5.96.0.tar.xz"
SRC_URI[sha256sum] = "b2f146a49649e15943f4caeee4968bf5298ad932b306dc8c75f888efaa68b9ca"

