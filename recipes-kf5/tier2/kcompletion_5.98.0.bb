# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kcompletion-5.98.0.tar.xz"
SRC_URI[sha256sum] = "4e33958a642764f91e32f8155ac6abacf1ed63fadec8d70c857bea0f408b3ba4"

