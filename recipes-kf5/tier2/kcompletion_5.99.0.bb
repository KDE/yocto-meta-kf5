# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kcompletion-5.99.0.tar.xz"
SRC_URI[sha256sum] = "4b54b28cd3318aa403a15735d537739662b7397879a4f478545b444a75b54793"

