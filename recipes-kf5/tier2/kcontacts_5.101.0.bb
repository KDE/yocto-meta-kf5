# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kcontacts-5.101.0.tar.xz"
SRC_URI[sha256sum] = "1d4c992bfc3c3c29690bb3bd5a762391e7d72829b6e69ecbebb186807071cbfa"

