# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kcontacts-5.102.0.tar.xz"
SRC_URI[sha256sum] = "de9892789c429c7715848d76177c90868969e555ab01be9f0c14c4322b12b113"

