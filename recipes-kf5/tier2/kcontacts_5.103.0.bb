# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kcontacts-5.103.0.tar.xz"
SRC_URI[sha256sum] = "53a3676ff5541e692868401b20461a2f0a3cb1c6b87617a53dbc05c6fca0d88c"

