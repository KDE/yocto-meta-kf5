# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kcontacts-5.104.0.tar.xz"
SRC_URI[sha256sum] = "d54063e4d23a839c702d964291931c9b35956f8ff94f80918a6cdb76e53852c9"

