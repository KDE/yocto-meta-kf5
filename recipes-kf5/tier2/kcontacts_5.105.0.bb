# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kcontacts-5.105.0.tar.xz"
SRC_URI[sha256sum] = "6dedd11f5327ee0522edd3538045084050c9e680ad4df4bd1e17342550bab338"

