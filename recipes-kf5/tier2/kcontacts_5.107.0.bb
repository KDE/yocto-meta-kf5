# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kcontacts-5.107.0.tar.xz"
SRC_URI[sha256sum] = "3bcaccf93e6cd0d283398c789a5975f2a9fc24724a73e2f07865e31fdf5fb09d"

