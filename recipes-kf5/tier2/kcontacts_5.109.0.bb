# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kcontacts-${PV}.tar.xz"
SRC_URI[sha256sum] = "091d5767d1678b2a1caf10ea3a7443d917b874a5687cad72fd6166ee6ed5ceaf"

