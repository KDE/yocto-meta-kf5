# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kcontacts-5.110.0.tar.xz"
SRC_URI[sha256sum] = "840c0322610f11dfd8ba7b5c91495a8df8dd3955c66ddc3c5c33151da9452b3e"

