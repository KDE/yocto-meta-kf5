# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kcontacts-5.83.0.tar.xz"
SRC_URI[sha256sum] = "24ad4239cbc935c1f5f6e50288f213b414b9b8e46574d0e1d18424609024c063"

