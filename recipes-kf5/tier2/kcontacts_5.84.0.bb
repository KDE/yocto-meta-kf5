# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kcontacts-5.84.0.tar.xz"
SRC_URI[sha256sum] = "d4fe2aa8d4ab47e50d86f268e7aa8790b068eb7e80bae908423a57c7dd9e7a3f"

