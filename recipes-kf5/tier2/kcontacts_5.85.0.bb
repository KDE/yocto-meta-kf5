# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kcontacts-5.85.0.tar.xz"
SRC_URI[sha256sum] = "134d0b10a17d386d00cfe25616e6410688e0f711dbbb52d992470ad31c82421e"

