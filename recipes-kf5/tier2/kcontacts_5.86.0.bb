# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kcontacts-5.86.0.tar.xz"
SRC_URI[sha256sum] = "81b5bc05d6ff721cc16f92938dda505a1e0ba5c46c557e37f981b65309fdb3a3"

