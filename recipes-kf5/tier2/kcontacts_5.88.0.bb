# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kcontacts-5.88.0.tar.xz"
SRC_URI[sha256sum] = "c5b975c2d935d38807634eb176d872fa45d6bca05136777714f5e729a50e42a0"

