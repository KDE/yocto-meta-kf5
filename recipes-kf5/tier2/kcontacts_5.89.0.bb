# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kcontacts-5.89.0.tar.xz"
SRC_URI[sha256sum] = "59949b9b3c40ae60597d7a44172ab600d2fe5262a2c96a72fd0ef535eccf4ffa"

