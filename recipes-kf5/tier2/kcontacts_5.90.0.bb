# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kcontacts-5.90.0.tar.xz"
SRC_URI[sha256sum] = "3536d335136c5bef49538a47641f3469668e45976874211ba74615d5cc08626f"

