# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kcontacts-5.93.0.tar.xz"
SRC_URI[sha256sum] = "5d7c8c6c6ccfa99188d9e4d7ab6165ec5b2bceea59a01edc6b309910fd604c75"

