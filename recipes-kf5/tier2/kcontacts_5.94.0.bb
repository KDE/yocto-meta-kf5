# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kcontacts-5.94.0.tar.xz"
SRC_URI[sha256sum] = "f7f317dfd9b270249cf168a699b39236490b5b21ec2ef1d186b59e29566252f8"

