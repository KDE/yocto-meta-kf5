# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kcontacts-5.96.0.tar.xz"
SRC_URI[sha256sum] = "4154c406fec42171a91a5d30fcd8456f6809eac04178fa2cf3f8384cd9e1b51c"

