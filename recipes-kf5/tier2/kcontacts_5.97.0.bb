# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kcontacts-5.97.0.tar.xz"
SRC_URI[sha256sum] = "b8196901ec5febcbfe961eb7a57ba41f3a5ed99a74a674c0a8fb5113eb93d908"

