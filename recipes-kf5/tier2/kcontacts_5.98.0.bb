# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kcontacts-5.98.0.tar.xz"
SRC_URI[sha256sum] = "0684e80bfd9a2b5674930c3efe6819be91e235122275d90f97f0bc9c6278743c"

