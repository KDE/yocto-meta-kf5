# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kcontacts-5.99.0.tar.xz"
SRC_URI[sha256sum] = "a5ab0691d844adedb698f4884acb9b3f3984a77755d9837d036d024a3b4262b8"

