require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "6fd5c71b0b949f92ab8d2f0f71d700ba729de7ca"
PV = "5.0.0"
