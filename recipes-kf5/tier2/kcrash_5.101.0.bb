# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kcrash-5.101.0.tar.xz"
SRC_URI[sha256sum] = "6dd10951db01918681a8ce6e9e3a99d3f8b5170d2c5a0b5212007e68db0c937a"

