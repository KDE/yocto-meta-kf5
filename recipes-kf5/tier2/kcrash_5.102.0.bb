# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kcrash-5.102.0.tar.xz"
SRC_URI[sha256sum] = "c7a8b303e76a0f7d26fbc823028f4d3231993ee080d6865b4935e3fda4a8d2c4"

