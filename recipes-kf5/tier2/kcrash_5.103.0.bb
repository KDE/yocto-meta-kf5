# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kcrash-5.103.0.tar.xz"
SRC_URI[sha256sum] = "3598a171f9162709b9020ed665520beab05104bfc8902c718c2fe788e7d7ebe7"

