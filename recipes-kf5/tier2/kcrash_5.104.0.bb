# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kcrash-5.104.0.tar.xz"
SRC_URI[sha256sum] = "12d6004f9e2e51a9d74f044462753dd7410e10a40a1f6b07727dcd5b52a7ea96"

