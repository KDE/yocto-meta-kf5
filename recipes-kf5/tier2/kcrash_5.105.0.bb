# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kcrash-5.105.0.tar.xz"
SRC_URI[sha256sum] = "ee087799922c9a74a7a8f523c75e8af61c27c3ded81b108c51e86faa2921e1c8"

