# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kcrash-5.110.0.tar.xz"
SRC_URI[sha256sum] = "cf40d5bb8308820db78f89a7011dc2f32504e811f91010c8f31430a74c064796"

