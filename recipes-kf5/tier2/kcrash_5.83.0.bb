# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kcrash-5.83.0.tar.xz"
SRC_URI[sha256sum] = "29ef0273ebd543be5bb9363efe5271fcaaea599463338d8ece625071decfa4c7"

