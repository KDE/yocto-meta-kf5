# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kcrash-5.85.0.tar.xz"
SRC_URI[sha256sum] = "ee9404564e13d6a4463891d592d8e78bee2fa9caf8074708fc18b44ae8b41392"

