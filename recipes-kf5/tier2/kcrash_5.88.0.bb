# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kcrash-5.88.0.tar.xz"
SRC_URI[sha256sum] = "9effa892a1ab726f3ddb3c025e600c2fa02496925fcb37a525d4ac5713199e3e"

