# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kcrash-5.90.0.tar.xz"
SRC_URI[sha256sum] = "8e002a52c48a5aaec72e85bcc30741b8b2493173030b3bca9e1de5bd3e966418"

