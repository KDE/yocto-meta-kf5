# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kcrash-5.93.0.tar.xz"
SRC_URI[sha256sum] = "2ff8d6c6924b2b752ef4a929390606bb55ce2aa55c582927269bd65556992dd6"

