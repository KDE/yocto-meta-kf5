# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kcrash-5.96.0.tar.xz"
SRC_URI[sha256sum] = "659bae2b46e40ae58a19564b18169149d7680df577f7fd0e7db2704a201d5c17"

