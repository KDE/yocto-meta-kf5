# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kcrash-5.98.0.tar.xz"
SRC_URI[sha256sum] = "6e9aee305e31fa89c38e905c66c917b11587922edbcac55f6f25dc27531f6a0d"

