# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kcrash-5.99.0.tar.xz"
SRC_URI[sha256sum] = "e896c42626252e5e0ddb63c469337a7208bc89700c158783cf82df081b67c3f2"

