# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kdoctools-5.101.0.tar.xz"
SRC_URI[sha256sum] = "6180aa6cd123986e0be18eaca706601388ff90a54e30d3169f06e2cabe5af847"

