# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kdoctools-5.102.0.tar.xz"
SRC_URI[sha256sum] = "23bc59ad1de668b03f81470d08e707be49a7c751a57ae7cf7400a84d6b38e685"

