# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kdoctools-5.107.0.tar.xz"
SRC_URI[sha256sum] = "9d56a0493f5fe10e7419ff97be56e4afbbc011eb19c379a42f5a58a860711550"

