# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kdoctools-5.110.0.tar.xz"
SRC_URI[sha256sum] = "923c7e2edbe948275317014ac3c57897ebc657f556a1d0c353f363c3ee7d05bc"

