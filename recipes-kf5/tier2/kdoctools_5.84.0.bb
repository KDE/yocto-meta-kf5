# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kdoctools-5.84.0.tar.xz"
SRC_URI[sha256sum] = "97e653793227600aec3a2236b61018e9c8c2fcfe5b73c94836f206ea558d0df4"

