# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kdoctools-5.85.0.tar.xz"
SRC_URI[sha256sum] = "c1c5505c42c221f2387b93e756c2d611f2494bb888af9c3d09993b57ccfd7d05"

