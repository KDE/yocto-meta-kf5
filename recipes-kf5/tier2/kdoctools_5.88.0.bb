# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kdoctools-5.88.0.tar.xz"
SRC_URI[sha256sum] = "14b00acc8129395cb7e523a7cb55ec6ddb479166c96693b7b13eefe285ec9030"

