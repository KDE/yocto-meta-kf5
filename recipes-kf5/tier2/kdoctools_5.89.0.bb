# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kdoctools-5.89.0.tar.xz"
SRC_URI[sha256sum] = "e1319af7ee5d108c651e3acb70ab28328d24be009de174646a233e2d7c2118f5"

