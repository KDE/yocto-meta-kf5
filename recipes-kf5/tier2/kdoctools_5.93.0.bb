# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kdoctools-5.93.0.tar.xz"
SRC_URI[sha256sum] = "25e83ff151c53667b94e25a5c41993796164683a43913820a5651f3610b65d5c"

