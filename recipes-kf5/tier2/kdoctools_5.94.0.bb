# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kdoctools-5.94.0.tar.xz"
SRC_URI[sha256sum] = "f54e61ffe8c5e634e7d6e341020b63346d40b524d4a22565c86b9147033cd2f4"

