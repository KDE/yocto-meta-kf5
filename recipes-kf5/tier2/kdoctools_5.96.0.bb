# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kdoctools-5.96.0.tar.xz"
SRC_URI[sha256sum] = "0b8101ee828fd5127bf213d740838e093a4d7b054407400041c9d9bada41d312"

