# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kdoctools-5.97.0.tar.xz"
SRC_URI[sha256sum] = "61ac72b2d338cddc6da57b9097287303117e0d49ccd1c717f69f38ac01150af6"

