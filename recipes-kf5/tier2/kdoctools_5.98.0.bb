# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kdoctools-5.98.0.tar.xz"
SRC_URI[sha256sum] = "1a32f311d63d0cf4a286d1e2cac87085da58656196b78cd858555bdfb492f779"

