# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kfilemetadata-5.101.0.tar.xz"
SRC_URI[sha256sum] = "53d8ec9b98814384e1c8f0ab2d158e41e5f228fa4bc3a288eef1d9a557e2e88b"

