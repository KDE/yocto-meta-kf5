# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kfilemetadata-5.102.0.tar.xz"
SRC_URI[sha256sum] = "cc893f0b0c151695dad05489aa248c86aa4efb7b5eb52b768550f371711e634f"

