# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kfilemetadata-5.103.0.tar.xz"
SRC_URI[sha256sum] = "498c9cfc82f455f2b74515c95061a92fe88ea6fb6db51867d6ea5249db9620c0"

