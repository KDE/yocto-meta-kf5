# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kfilemetadata-5.104.0.tar.xz"
SRC_URI[sha256sum] = "1e4f199e1eeec6a7a173172e234c42423381e756aef36e74bd6fb1e96d6dd504"

