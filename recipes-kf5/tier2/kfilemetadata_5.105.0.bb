# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kfilemetadata-5.105.0.tar.xz"
SRC_URI[sha256sum] = "c64ef2bab192c779cafe471354a2125fff858ba8e8a65d2193965ee520b02e2b"

