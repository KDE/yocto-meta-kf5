# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kfilemetadata-5.107.0.tar.xz"
SRC_URI[sha256sum] = "edb4f34d45b7c898bc349833dfde7e82cc9ba9f2d1af53a89d8b7ef0ebbc8aad"

