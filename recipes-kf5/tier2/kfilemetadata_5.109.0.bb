# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kfilemetadata-${PV}.tar.xz"
SRC_URI[sha256sum] = "b524da82cbbb69dee00acf1e30912b448ccc0aed0e455d4091e1e97d0890b4ea"

