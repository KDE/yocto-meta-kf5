# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kfilemetadata-5.110.0.tar.xz"
SRC_URI[sha256sum] = "892ec8817ab6f75ff5bc86c7efa6ee10e76155d2a3421dd290f6ee822322aa1e"

