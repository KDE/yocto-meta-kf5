# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kfilemetadata-5.83.0.tar.xz"
SRC_URI[sha256sum] = "d65dff0ede7eb7e823bce6da9f8e3359cb39a40c046f2ea578a321e85594098e"

