# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kfilemetadata-5.86.0.tar.xz"
SRC_URI[sha256sum] = "6a72d90c6f0017cfaeea372817a4d271eaf3cc42fd09a1bab04790136d5251cf"

