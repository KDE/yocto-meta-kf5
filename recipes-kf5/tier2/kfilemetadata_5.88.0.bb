# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kfilemetadata-5.88.0.tar.xz"
SRC_URI[sha256sum] = "727013fda110a5423d1aabefc6d24a642a3d561ff33babed04e46d8b0c97838b"

