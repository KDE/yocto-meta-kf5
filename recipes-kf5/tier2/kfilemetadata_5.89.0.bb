# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kfilemetadata-5.89.0.tar.xz"
SRC_URI[sha256sum] = "658087fd33864e73bee4c78f4da11b3039c4d7e50ac6fc0a68ed56199bf64b11"

