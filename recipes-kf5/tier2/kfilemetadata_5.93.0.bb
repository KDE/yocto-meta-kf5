# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kfilemetadata-5.93.0.tar.xz"
SRC_URI[sha256sum] = "3015c071a5f068f6e45d36238aa0243d3788a95ec84362ba79ed0369e676a816"

