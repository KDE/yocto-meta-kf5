# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kfilemetadata-5.94.0.tar.xz"
SRC_URI[sha256sum] = "7f573b1a30349e331309dcf9e3374d7a304b6bdd0453a122366f7bd2574977e6"

