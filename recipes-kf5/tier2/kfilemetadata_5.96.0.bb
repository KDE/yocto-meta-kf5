# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kfilemetadata-5.96.0.tar.xz"
SRC_URI[sha256sum] = "7809a54aadf8a37a73652e16fcf152e5230581502c4252cb75070083a9aa036a"

