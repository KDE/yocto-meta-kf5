# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kfilemetadata-5.97.0.tar.xz"
SRC_URI[sha256sum] = "3f2fd85176d7550de8f0af31ba90976b6b50ed277f7c881d1666e082edd07021"

