# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kfilemetadata-5.98.0.tar.xz"
SRC_URI[sha256sum] = "7666c30cc99a1c09344bdbf2fdbfdc591b48c3481f4559f2702e4ea121d55bdb"

