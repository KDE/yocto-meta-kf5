# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kfilemetadata-5.99.0.tar.xz"
SRC_URI[sha256sum] = "7a1fcdb4505c9a6333272304e95651b6b5e41061095e1b4438aa2066b41dd196"

