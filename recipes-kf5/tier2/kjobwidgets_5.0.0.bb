require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "511abe938b2937eb12ab588be81430b17e70da8a"
PV = "5.0.0"
