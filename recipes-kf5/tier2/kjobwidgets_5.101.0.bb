# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kjobwidgets-5.101.0.tar.xz"
SRC_URI[sha256sum] = "e1a975b8beb24086dea1fcf1657ff9e672734f80244483c920e960d258cb9a26"

