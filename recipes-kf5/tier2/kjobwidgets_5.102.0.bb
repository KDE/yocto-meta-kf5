# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kjobwidgets-5.102.0.tar.xz"
SRC_URI[sha256sum] = "94e1badb9709ad42da32ac3a006b84618d7f42f7d1be0a8385493a0e4974dde4"

