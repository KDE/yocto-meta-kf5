# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kjobwidgets-5.103.0.tar.xz"
SRC_URI[sha256sum] = "fa350ac797cb7d4da1d823a09b3036cd91710df7f23c795ee190004949ff4886"

