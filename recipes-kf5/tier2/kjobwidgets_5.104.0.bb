# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kjobwidgets-5.104.0.tar.xz"
SRC_URI[sha256sum] = "3b254124d3bf20666a514710fef8990325da2ade14f49368b1bed1256eb8fea1"

