# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kjobwidgets-5.105.0.tar.xz"
SRC_URI[sha256sum] = "b7edaccfa5d17b4bd9c6c4ebbb77cb951719fa405ca0b31da5af316acf7edee6"

