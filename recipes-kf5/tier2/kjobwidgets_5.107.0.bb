# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kjobwidgets-5.107.0.tar.xz"
SRC_URI[sha256sum] = "26e1ab6bdec59890be9155841f74bb79d1fedddcafb674a8e6a257f8c2906b92"

