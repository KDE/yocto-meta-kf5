# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kjobwidgets-${PV}.tar.xz"
SRC_URI[sha256sum] = "860ed5b80d868c42ff957c9d1003d542f9b7fe026c877786dc14969d50a7c2b7"

