# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kjobwidgets-5.110.0.tar.xz"
SRC_URI[sha256sum] = "02861c662ab3b70e137eb805395601c93b231dd245bf5855bc31c03ad58b87ae"

