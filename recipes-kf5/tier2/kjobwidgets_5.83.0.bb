# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kjobwidgets-5.83.0.tar.xz"
SRC_URI[sha256sum] = "f3b9371a77ee245a60ea808f2e6928575187ac06b34818b76f1c147dfb95b5e7"

