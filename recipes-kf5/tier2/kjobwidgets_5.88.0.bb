# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kjobwidgets-5.88.0.tar.xz"
SRC_URI[sha256sum] = "5131391391372d71ee4d2a832c45fa5e2d2c8a02c0df61078451551b50b8ba26"

