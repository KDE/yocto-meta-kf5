# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kjobwidgets-5.89.0.tar.xz"
SRC_URI[sha256sum] = "6871014b4ee25faba9eeab6224ca4dbeb75de0f8962b078eae34a922ec6fda0b"

