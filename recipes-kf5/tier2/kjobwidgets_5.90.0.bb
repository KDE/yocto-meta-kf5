# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kjobwidgets-5.90.0.tar.xz"
SRC_URI[sha256sum] = "0d65d194284d2d8097d16c7d031772d29886316985e3274db3b06b5a916163cb"

