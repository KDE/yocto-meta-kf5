# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kjobwidgets-5.93.0.tar.xz"
SRC_URI[sha256sum] = "62449b747d6fa5b32a1cb317b2b614172e42be3b85f39b02d6a07adc267c39fb"

