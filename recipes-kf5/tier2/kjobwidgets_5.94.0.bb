# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kjobwidgets-5.94.0.tar.xz"
SRC_URI[sha256sum] = "014f45fca82886af463956c533f5ba868700ac7ec61733f35a7fabad0042b007"

