# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kjobwidgets-5.96.0.tar.xz"
SRC_URI[sha256sum] = "b4090c614f64ef7567c560c402ad05c81d4c5ba10c9522021247064ced4e30f0"

