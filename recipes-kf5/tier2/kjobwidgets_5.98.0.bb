# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kjobwidgets-5.98.0.tar.xz"
SRC_URI[sha256sum] = "8c93ee321559fd515898e4b5f33a5b1c8190a404cdd5287ef0c909385ab10739"

