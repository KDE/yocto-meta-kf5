# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kjobwidgets-5.99.0.tar.xz"
SRC_URI[sha256sum] = "06f7e9cdb082f093e3451dbe2a801d95e822396c7b5e9c190d94179138bb98fb"

