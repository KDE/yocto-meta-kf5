# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/knotifications-5.101.0.tar.xz"
SRC_URI[sha256sum] = "38ca69da882d22be43ec7736e08104f74df8dd31c9aaeffc2b0597439cff5d1b"

