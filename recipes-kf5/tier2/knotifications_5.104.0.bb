# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/knotifications-5.104.0.tar.xz"
SRC_URI[sha256sum] = "c76d0293e97fe73e72c7b1f7f3d47065bf488086ccd83142d7886525cfc40d18"

