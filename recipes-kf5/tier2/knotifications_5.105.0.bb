# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/knotifications-5.105.0.tar.xz"
SRC_URI[sha256sum] = "2b24ed1f92be045c8f6d2c7c39c9f3c7948a8bcbdb35f7af6f61f076cd845535"

