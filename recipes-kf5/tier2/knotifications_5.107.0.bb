# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/knotifications-5.107.0.tar.xz"
SRC_URI[sha256sum] = "ee1d477046c54d03d7704bc76a7d583393e8ba316e5c622d39ca35fd98a92f76"

