# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/knotifications-${PV}.tar.xz"
SRC_URI[sha256sum] = "12b1b41c80739dcdda0cff1d81288323b8b5cb8249da45ecee4b785c604dc13d"

