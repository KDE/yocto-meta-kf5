# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/knotifications-5.110.0.tar.xz"
SRC_URI[sha256sum] = "f5195f2d6de921e4529239f58411c0d03d7bb930495edeee58f8b5b4cd68a37e"

