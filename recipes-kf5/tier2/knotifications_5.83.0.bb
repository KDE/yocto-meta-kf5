# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/knotifications-5.83.0.tar.xz"
SRC_URI[sha256sum] = "2cc2a9bf03733c38e70767dcd90da9957e7b6432b0308e5924609bcf52728d05"

