# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/knotifications-5.84.0.tar.xz"
SRC_URI[sha256sum] = "b09c4d6091a793673019dbbe2d4934747f6a5b2cd5f78c59c054a189154a5f09"

