# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/knotifications-5.85.0.tar.xz"
SRC_URI[sha256sum] = "255aef490cb178d63a692423e3ad341323153a91de7440152322366175492663"

