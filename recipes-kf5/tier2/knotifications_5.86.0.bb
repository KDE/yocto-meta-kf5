# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/knotifications-5.86.0.tar.xz"
SRC_URI[sha256sum] = "ea178707fe6d402aa576f651502d82107b216c664992f5c160ba521e645d5034"

