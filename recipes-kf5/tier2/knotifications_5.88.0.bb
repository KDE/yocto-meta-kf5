# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/knotifications-5.88.0.tar.xz"
SRC_URI[sha256sum] = "f4822b18a9315eaf06b705b89538b28546cacf1938689d0a3d6d6974b9f90522"

