# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/knotifications-5.89.0.tar.xz"
SRC_URI[sha256sum] = "1aae7dfb2d9d79c8e55d6aabd88b699d6cacc5c70d50a1990efe838bb9baf0c9"

