# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/knotifications-5.90.0.tar.xz"
SRC_URI[sha256sum] = "f19d4a2a928da505d3d99cf66967017a8eb9488bbc356e6e23e8075fa01c0b97"

