# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/knotifications-5.93.0.tar.xz"
SRC_URI[sha256sum] = "fe191b1fe55881d7e212a3b70fe08d53e47c32793d38f5d5a4d82b796796da4b"

