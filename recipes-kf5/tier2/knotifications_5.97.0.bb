# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/knotifications-5.97.0.tar.xz"
SRC_URI[sha256sum] = "e36364141e715b2b06e583f3f991fa4dcd627822d2887b76b9cc98653dc0d41f"

