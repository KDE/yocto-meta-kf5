# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/knotifications-5.98.0.tar.xz"
SRC_URI[sha256sum] = "8d6145cf77c18553d4f44149038c0d5578fd7006454423d76e5d352af9c89083"

