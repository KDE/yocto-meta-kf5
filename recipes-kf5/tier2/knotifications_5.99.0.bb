# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/knotifications-5.99.0.tar.xz"
SRC_URI[sha256sum] = "36b1126801f649b26fb77889a35874519e3f7033faa55cff20e965581c5c302b"

