# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kpackage-5.101.0.tar.xz"
SRC_URI[sha256sum] = "6cdb5e6aeb8f45dcd0cef4863edb698cee0fdd216171c00aa5acf5c75cdc1f1d"

