# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kpackage-5.102.0.tar.xz"
SRC_URI[sha256sum] = "83d891ea7d35c3d3b0745fd75af31b6495fa5ec67503b5ed9091d134701b5a55"

