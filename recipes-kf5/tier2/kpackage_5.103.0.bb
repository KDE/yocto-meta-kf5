# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kpackage-5.103.0.tar.xz"
SRC_URI[sha256sum] = "6b5b04be5c01a123fd5158ac2a62fb0aac823bb68a0d80b4daf537c460699b95"

