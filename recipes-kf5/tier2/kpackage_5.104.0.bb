# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kpackage-5.104.0.tar.xz"
SRC_URI[sha256sum] = "e7288a56be7ed3ef9f65b94ab90b4002f2be4403e0eef7433a73ecce5ca185a4"

