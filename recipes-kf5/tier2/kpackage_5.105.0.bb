# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kpackage-5.105.0.tar.xz"
SRC_URI[sha256sum] = "ccae4d5556ddb6392b5c9f2423ef4b170adc7d2e5c4764a44b73a21b1c4a6765"

