# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kpackage-5.107.0.tar.xz"
SRC_URI[sha256sum] = "f0ae60c1556ab7156f39191609386b84d103d44cda3eccbd294e73a983c404b2"

