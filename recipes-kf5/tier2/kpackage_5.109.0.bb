# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kpackage-${PV}.tar.xz"
SRC_URI[sha256sum] = "782dacbe61c904bb3efac23edf2613d722f71509c2111dd0cde498f062adbf3b"

