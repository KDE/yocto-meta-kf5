# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kpackage-5.110.0.tar.xz"
SRC_URI[sha256sum] = "2d26444dcd801616b72001c7995741dd46bdb9b622feb14c4b50fd7e4f2da8c9"

