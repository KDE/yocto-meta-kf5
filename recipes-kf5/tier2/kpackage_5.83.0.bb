# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kpackage-5.83.0.tar.xz"
SRC_URI[sha256sum] = "ac950083ba66429e5e7c0898dd911210a22b12a9421ddc05c28d74dcbdb7801e"

