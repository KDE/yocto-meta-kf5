# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kpackage-5.84.0.tar.xz"
SRC_URI[sha256sum] = "6761f2220e17e10afd6944cc58b3e8bdc3cb691e0098893299b827e20b62cc98"

