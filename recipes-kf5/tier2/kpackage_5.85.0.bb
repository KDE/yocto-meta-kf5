# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kpackage-5.85.0.tar.xz"
SRC_URI[sha256sum] = "b2c6c90e5a9b3c46fe0fad06ab58f7356447e3c90213882c8006683b59c13c93"

