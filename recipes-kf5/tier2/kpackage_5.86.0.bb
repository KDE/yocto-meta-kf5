# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kpackage-5.86.0.tar.xz"
SRC_URI[sha256sum] = "2b3ca304ed7397f03aa71d5cfc11a7877e9fe9f8fb72aad26e80ee2f0815a2cf"

