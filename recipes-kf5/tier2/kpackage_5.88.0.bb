# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kpackage-5.88.0.tar.xz"
SRC_URI[sha256sum] = "9d4c8e5c44c14b0b020c8c71c6da64c78761ee01766874efed5f3077b86600ff"

