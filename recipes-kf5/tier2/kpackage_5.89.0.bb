# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kpackage-5.89.0.tar.xz"
SRC_URI[sha256sum] = "438395b60cf66632423f9410f6f0e02b0fd7bfeaa9cf2d680d21a72df20316a5"

