# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kpackage-5.90.0.tar.xz"
SRC_URI[sha256sum] = "e08ff2a2d363d56a382dccf5253108df66d62ab6f1d50bb6d26014a4b94a2fe6"

