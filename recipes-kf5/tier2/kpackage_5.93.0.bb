# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kpackage-5.93.0.tar.xz"
SRC_URI[sha256sum] = "8de6ecd6ed1cf746b9919d93283aa650922211b51bb2d22027102f67c42ec5cd"

