# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kpackage-5.96.0.tar.xz"
SRC_URI[sha256sum] = "0d694ebc7227fc1b5d9cc0f91d3e82926c833870433dc8f6baea1085ef8f5d3f"

