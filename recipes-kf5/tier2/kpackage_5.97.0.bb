# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kpackage-5.97.0.tar.xz"
SRC_URI[sha256sum] = "2c1dd7b2ecf54a5356e89037977703f9d15970dab0e3ac455f969e6d1741410e"

