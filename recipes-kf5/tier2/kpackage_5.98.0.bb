# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kpackage-5.98.0.tar.xz"
SRC_URI[sha256sum] = "fe9261b0fc16019fd8c055f1d4494e4b055db8f9d1cee954f902438c13966488"

