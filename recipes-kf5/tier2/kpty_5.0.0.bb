require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "9ad950b78394e737bd0a03e207cc701ed4d17790"
PV = "5.0.0"
