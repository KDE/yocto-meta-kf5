# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kpty-5.101.0.tar.xz"
SRC_URI[sha256sum] = "4eed2f2e0df3f5c50640483c29c1ae6c4998ac0058faebb996d2d1a25a60c860"

