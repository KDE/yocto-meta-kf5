# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kpty-5.102.0.tar.xz"
SRC_URI[sha256sum] = "ff95c35d5cd5757e606d86aa386449e43a652992767def136a759f2de976a738"

