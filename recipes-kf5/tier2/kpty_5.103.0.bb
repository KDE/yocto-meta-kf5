# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kpty-5.103.0.tar.xz"
SRC_URI[sha256sum] = "9ae6f89378f117ec5ff49d398acc848d5bc8fb6f1d5cda28cfcd65627580ea49"

