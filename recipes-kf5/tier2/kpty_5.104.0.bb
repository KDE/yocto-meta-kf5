# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kpty-5.104.0.tar.xz"
SRC_URI[sha256sum] = "bf252e249385d80b935c085be500fea9fca649751322678802bb110d90ea5506"

