# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kpty-5.105.0.tar.xz"
SRC_URI[sha256sum] = "ba2ceac1b9678b6e926119c3e040e2f9cf277dca8c9ecf0f9ca5f58fdfd0616a"

