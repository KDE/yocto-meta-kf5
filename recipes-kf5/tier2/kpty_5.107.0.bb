# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kpty-5.107.0.tar.xz"
SRC_URI[sha256sum] = "907ec5f4108d42fcfc7013c38e97c71ced2002dc14d311b589170e89ae4813f8"

