# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kpty-${PV}.tar.xz"
SRC_URI[sha256sum] = "980662b902ceaf6275f324086da0019621bc86ad6e9c7f9e60bbb0773c051cf0"

