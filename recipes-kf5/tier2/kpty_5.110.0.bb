# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kpty-5.110.0.tar.xz"
SRC_URI[sha256sum] = "fa8ab4e0329a60e257cdff5bad5f3700e055d783e9f3b436f08afe14bfe6a9b3"

