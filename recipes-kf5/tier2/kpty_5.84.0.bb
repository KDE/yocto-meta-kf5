# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kpty-5.84.0.tar.xz"
SRC_URI[sha256sum] = "62297b5a891f156d1bf7b0d8ed5996d40c30917800ebdabbfadcf32dccc70613"

