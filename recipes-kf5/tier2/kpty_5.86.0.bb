# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kpty-5.86.0.tar.xz"
SRC_URI[sha256sum] = "754accb56308b4c07a38294d3e873d90ec9471448a572a05ed2a8d298615ece5"

