# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kpty-5.89.0.tar.xz"
SRC_URI[sha256sum] = "9d44b05472940105b6230722d983bec7b59ee584756ccc07a882870646d7a300"

