# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kpty-5.90.0.tar.xz"
SRC_URI[sha256sum] = "8a30a43d8c0397eb3657f578da6836872468d2eb49277961be9c73e073f2b6dc"

