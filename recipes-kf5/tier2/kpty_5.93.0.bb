# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kpty-5.93.0.tar.xz"
SRC_URI[sha256sum] = "2a05154dbf9eb082f32f33b494dc36c3b24a59c14521167f3306a04c3649ec12"

