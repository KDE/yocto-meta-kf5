# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kpty-5.94.0.tar.xz"
SRC_URI[sha256sum] = "569a60318b54cca6a5c5fb1e182556010d2f4c052961b125ad852ffa015746ca"

