# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kpty-5.96.0.tar.xz"
SRC_URI[sha256sum] = "3732905762c4956e7af08b925c81e55bb4fced92ebf7ed3929866d88cdde5c97"

