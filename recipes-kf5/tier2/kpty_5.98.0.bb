# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kpty-5.98.0.tar.xz"
SRC_URI[sha256sum] = "9c0b54024c9aac7fb2f91201bbf1cd5e41d21a9ffbeed0cb63d9f2467b5b3d2b"

