# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kpty-5.99.0.tar.xz"
SRC_URI[sha256sum] = "a08489301dba85a766e2e6acbd62bf7faedd3d68279e0b2b1637541bebd0e86d"

