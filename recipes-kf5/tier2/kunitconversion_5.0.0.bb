require ${PN}.inc

SRC_URI = "${GIT_REPO}"
SRCREV = "03faceaf5f0fd9aac0579bb067428ffac9554954"
PV = "5.0.0"
