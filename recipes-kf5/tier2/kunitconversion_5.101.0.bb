# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kunitconversion-5.101.0.tar.xz"
SRC_URI[sha256sum] = "7bb2c342a549b5847b44a852c8ab85e48a5509201980f1ff98961c3096868c48"

