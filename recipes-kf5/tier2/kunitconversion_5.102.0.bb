# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kunitconversion-5.102.0.tar.xz"
SRC_URI[sha256sum] = "a3d5206ca8dadd16ba972a21eca2cd7074ba95dfd83022e2faa0e95cf87f8d87"

