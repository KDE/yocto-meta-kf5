# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kunitconversion-5.103.0.tar.xz"
SRC_URI[sha256sum] = "ede791e5fc130042fcd75f06c15ebccedc33f51888f4cb5620e91c6c49fcb077"

