# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kunitconversion-5.104.0.tar.xz"
SRC_URI[sha256sum] = "509883a601936ba283f8b260c6d6bb030a1720deeb4c7255bc5272ef6b1ed7a8"

