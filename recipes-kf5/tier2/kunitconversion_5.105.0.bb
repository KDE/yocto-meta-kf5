# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kunitconversion-5.105.0.tar.xz"
SRC_URI[sha256sum] = "3f69545481bebf0dc69fcad43defb429e1b0306550380115edaf41a84086144e"

