# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kunitconversion-5.107.0.tar.xz"
SRC_URI[sha256sum] = "5cf5beed75848efbec729eedee337b340a273a660f38b2e6197ae303277e26f9"

