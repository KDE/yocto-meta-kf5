# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kunitconversion-${PV}.tar.xz"
SRC_URI[sha256sum] = "14ba09623cc7c86c36964889bcff6760bfddef9ee5257c9578b38eaa8cc486d8"

