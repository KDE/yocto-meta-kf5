# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kunitconversion-5.110.0.tar.xz"
SRC_URI[sha256sum] = "aafd3fbbf77a3ae1a9600c1b8199531c15ccf1c07e80fa317a429e12fe037c20"

