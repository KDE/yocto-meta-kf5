# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kunitconversion-5.83.0.tar.xz"
SRC_URI[sha256sum] = "6e82f0024256c9da5a4892e96f28c19377e4859dceb78333de6ad0a2c6617105"

