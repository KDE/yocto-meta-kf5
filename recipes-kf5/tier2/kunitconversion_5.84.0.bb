# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kunitconversion-5.84.0.tar.xz"
SRC_URI[sha256sum] = "aed3cacfcc5cef8f4f51b84bcf5f84f634b6871849471c9c73ba79c2f7601229"

