# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kunitconversion-5.85.0.tar.xz"
SRC_URI[sha256sum] = "1e0af3093cf376790a22ef80bf3df094c57ffcd9427da6ba73089e6a71ab9665"

