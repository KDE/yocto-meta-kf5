# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kunitconversion-5.88.0.tar.xz"
SRC_URI[sha256sum] = "6cd307174e96702a051d96328527e3890f24874ae7a58195257ea9689a097e16"

