# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kunitconversion-5.89.0.tar.xz"
SRC_URI[sha256sum] = "38bc211579d20863583236599bebe7b1b579da266e64eed1506b611435a3b6ae"

