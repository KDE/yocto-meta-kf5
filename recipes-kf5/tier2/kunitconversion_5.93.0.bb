# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kunitconversion-5.93.0.tar.xz"
SRC_URI[sha256sum] = "9baefb6aed92d2b32727f9492f1322a9e0b17b609c2d82296f4ee10b55a02fc8"

