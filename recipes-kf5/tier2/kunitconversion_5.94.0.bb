# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kunitconversion-5.94.0.tar.xz"
SRC_URI[sha256sum] = "e4adf0f124db45134042e706b466c30e531398996f872294119887af9ca38049"

