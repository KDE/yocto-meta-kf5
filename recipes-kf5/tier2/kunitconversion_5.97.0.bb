# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kunitconversion-5.97.0.tar.xz"
SRC_URI[sha256sum] = "dbf85e140736132f89f01b939627aa40c40ef2f7913addd63d7e7ba3e6a957df"

