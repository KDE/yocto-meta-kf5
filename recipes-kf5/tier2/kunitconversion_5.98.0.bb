# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kunitconversion-5.98.0.tar.xz"
SRC_URI[sha256sum] = "0564c3b2845b76ab6d8e3fb35a233d81916bc0aac87f4ad2c4b388195a781e52"

