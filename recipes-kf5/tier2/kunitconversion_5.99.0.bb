# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kunitconversion-5.99.0.tar.xz"
SRC_URI[sha256sum] = "dea28a89f4bff58fa8c62a09847f8837111940a0757e312c32f70b499224a42f"

