# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/syndication-5.101.0.tar.xz"
SRC_URI[sha256sum] = "c005c3393f17a89f2a467ad7c38cd06e8beb4c67a281e9344a7a909bdd84e2c1"

