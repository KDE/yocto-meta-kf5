# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/syndication-5.102.0.tar.xz"
SRC_URI[sha256sum] = "299d7c25a0ada9f8ed2a97c1e7cc256f75ba32f1ea4f619cb3956438887508f0"

