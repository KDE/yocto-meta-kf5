# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/syndication-5.103.0.tar.xz"
SRC_URI[sha256sum] = "cf5a8406dc2cf37a77d209be4c487c77bf94f336cb3b6d08b78fb349e072f680"

