# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/syndication-5.104.0.tar.xz"
SRC_URI[sha256sum] = "8bb1d60ec3495d1f0bf4c5488e9c86a8791965a27cee2d7f022aae482c25bf51"

