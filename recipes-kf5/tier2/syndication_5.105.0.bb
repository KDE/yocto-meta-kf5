# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/syndication-5.105.0.tar.xz"
SRC_URI[sha256sum] = "6b626f094569a3069856239933e3602c96652c03e3add04743bb7b793714c5e3"

