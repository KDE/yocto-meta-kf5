# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/syndication-5.107.0.tar.xz"
SRC_URI[sha256sum] = "254d38c51f77e3e98b78761490258d394151f07b5e5ad19113061ff5c9b0f84a"

