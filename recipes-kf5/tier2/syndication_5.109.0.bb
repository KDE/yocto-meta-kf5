# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/syndication-${PV}.tar.xz"
SRC_URI[sha256sum] = "2561a206b8e1e51bee3a5888429335ce4dbf4c9fd1f8c112f6089a2dd3d815ca"

