# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/syndication-5.110.0.tar.xz"
SRC_URI[sha256sum] = "4da373fab1f75892d94d066d9cbed06e2d7ad48a39dfb7b26d2e6d3759014d37"

