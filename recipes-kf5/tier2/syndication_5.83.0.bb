# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/syndication-5.83.0.tar.xz"
SRC_URI[sha256sum] = "5fdfa819dd43c4b7c31a3014b080c2e5c09e312a19e6858907da79fd0d42e25f"

