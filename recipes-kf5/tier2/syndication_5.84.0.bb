# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/syndication-5.84.0.tar.xz"
SRC_URI[sha256sum] = "2cf3e9f67bce39fdbfd915d5ab3942e62671d424d5bf997e4688cf56ee2e4454"

