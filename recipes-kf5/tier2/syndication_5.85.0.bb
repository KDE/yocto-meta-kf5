# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/syndication-5.85.0.tar.xz"
SRC_URI[sha256sum] = "b037497b677684751162856808b05dc6eec67c8378cbabba16ecb74d7fff1b16"

