# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/syndication-5.86.0.tar.xz"
SRC_URI[sha256sum] = "ee34b1fd872fd6a1badc4f7ea880abfb6b0e61374f4b117fa3a1e38ed79b6b8e"

