# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/syndication-5.88.0.tar.xz"
SRC_URI[sha256sum] = "09008afd3add5f57942d21d50328ffcd013aff9ea942d6b188069bc6a1ae9638"

