# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/syndication-5.89.0.tar.xz"
SRC_URI[sha256sum] = "9ca5078a6a7bba689a8ab8786c1cfb0fee5788e95eddf4dbf9dc3d28c5e0cda0"

