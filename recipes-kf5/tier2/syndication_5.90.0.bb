# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/syndication-5.90.0.tar.xz"
SRC_URI[sha256sum] = "bdfe30c05bbdd8e10903fe69a37cf859f25984edae16283fdd5c0ac207213229"

