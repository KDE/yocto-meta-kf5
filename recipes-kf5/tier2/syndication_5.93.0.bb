# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/syndication-5.93.0.tar.xz"
SRC_URI[sha256sum] = "35f14e36076760170df44785df39f522407f58cfa36faf91564696587d8eda23"

