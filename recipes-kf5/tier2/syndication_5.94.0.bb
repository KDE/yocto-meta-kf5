# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/syndication-5.94.0.tar.xz"
SRC_URI[sha256sum] = "458e12e4d4898d5e660ea6a3fe0d6158c208f5d4176451e1132423df2044685b"

