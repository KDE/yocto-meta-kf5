# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/syndication-5.96.0.tar.xz"
SRC_URI[sha256sum] = "a4b1dbf8c0eed15eab9f520512fee6271b07fac0745c2b1fc6ccae49ed6fc0e0"

