# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/syndication-5.97.0.tar.xz"
SRC_URI[sha256sum] = "560262fe64af2891e457b4b123330be03bbf2bbb3b3fc29b657ee19fa3ae9d61"

