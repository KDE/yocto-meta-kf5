# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/syndication-5.98.0.tar.xz"
SRC_URI[sha256sum] = "5de59a9d77bf3a72dc6b73ebd304b92c6d0ef05cd233ac9b6f71cf0e0142fe12"

