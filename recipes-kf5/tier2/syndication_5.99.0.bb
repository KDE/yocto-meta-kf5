# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/syndication-5.99.0.tar.xz"
SRC_URI[sha256sum] = "e29898500a85c3327f4dc078746c08cf44b6e523b070ba49d65a572e14a8cfd1"

