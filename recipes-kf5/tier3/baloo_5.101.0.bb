# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/baloo-5.101.0.tar.xz"
SRC_URI[sha256sum] = "89ac03d2fcd6c79aeff9f77268d5b7f53c8820fd45740b7c0d148fe2ae3a003c"

