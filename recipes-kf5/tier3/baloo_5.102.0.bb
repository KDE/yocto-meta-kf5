# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/baloo-5.102.0.tar.xz"
SRC_URI[sha256sum] = "ddac3964c3a05e50c996bfe5682802e14f31900102dd72d6ad2c7f18db61dd78"

