# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/baloo-5.103.0.tar.xz"
SRC_URI[sha256sum] = "b3ea1481b9fe77307287dc764eb5c7bd4c5ecc6c58e074be3a91b496c4e6a580"

