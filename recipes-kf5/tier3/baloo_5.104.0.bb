# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/baloo-5.104.0.tar.xz"
SRC_URI[sha256sum] = "9a721f7a71a5daafab067ac465b78326868f1184c17579a66f875d92c1a7732a"

