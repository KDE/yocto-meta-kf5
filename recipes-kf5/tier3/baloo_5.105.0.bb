# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/baloo-5.105.0.tar.xz"
SRC_URI[sha256sum] = "8d3f7e1acabf6993d2e724b8318c270d66812f5295ae66047c19b3ec5ab1f4c5"

