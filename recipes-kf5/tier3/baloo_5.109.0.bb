# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/baloo-${PV}.tar.xz"
SRC_URI[sha256sum] = "936f96597bb25a23f4ff5eb8df2b08e7fe444741a681a8d766f2f234720a5be6"

