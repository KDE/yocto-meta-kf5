# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/baloo-5.110.0.tar.xz"
SRC_URI[sha256sum] = "36a85d71cacc7384531e84f7f363cbf4ad0c41637ca1678f9a35dc7faeb7e22d"

