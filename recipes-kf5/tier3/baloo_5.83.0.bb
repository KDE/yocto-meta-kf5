# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/baloo-5.83.0.tar.xz"
SRC_URI[sha256sum] = "5aafaa13aa431249bb1479c24cb61952729546a1c27bbc7c60c460a10fd0102a"

