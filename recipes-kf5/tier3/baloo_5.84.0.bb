# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/baloo-5.84.0.tar.xz"
SRC_URI[sha256sum] = "e4c1df50e8218d2e227a31499c4016cde546b13361e46994ed82fb8c13768d96"

