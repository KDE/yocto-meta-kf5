# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/baloo-5.86.0.tar.xz"
SRC_URI[sha256sum] = "47ce609d9eb17375c5b0bbe3fc5d0137b3fc6c097bd1d942399ad42ff7ffa97c"

