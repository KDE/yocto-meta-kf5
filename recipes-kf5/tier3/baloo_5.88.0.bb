# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/baloo-5.88.0.tar.xz"
SRC_URI[sha256sum] = "09018da3a01c21e9a8369841fa033737e1b93b56f2b2837663e657ff076abc3d"

