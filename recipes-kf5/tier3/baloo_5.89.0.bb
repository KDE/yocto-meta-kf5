# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/baloo-5.89.0.tar.xz"
SRC_URI[sha256sum] = "3a7aa9a67c063c14d4de6f749836da9514191fdf4ab3607427b56645ec972f24"

