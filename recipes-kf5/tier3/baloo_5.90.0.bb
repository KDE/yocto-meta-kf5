# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/baloo-5.90.0.tar.xz"
SRC_URI[sha256sum] = "a64483982a68160a9ce38326abce89d6e57b6b7e1907e4a2683b46df90f6ceda"

