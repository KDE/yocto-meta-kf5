# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/baloo-5.94.0.tar.xz"
SRC_URI[sha256sum] = "9dc4182e5803c32a47d6a82588f6a6b36837fb44a90fe4404750886150b9273a"

