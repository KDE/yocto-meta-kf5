# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/baloo-5.97.0.tar.xz"
SRC_URI[sha256sum] = "1f869c0eecca5b27bac4b51a29f5782725f2123430946e6a8f1fcc56beba5968"

