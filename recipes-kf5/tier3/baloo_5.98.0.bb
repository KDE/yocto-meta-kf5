# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/baloo-5.98.0.tar.xz"
SRC_URI[sha256sum] = "3c8778cb3d0fe8139af2152499270013a1f8eb09988814cbd696febc2d2da174"

