# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kactivities-stats-5.101.0.tar.xz"
SRC_URI[sha256sum] = "77b18099a03114e8a8a3057585bd252a6d85fc0bf826acfbbcdeaf37fe173085"

