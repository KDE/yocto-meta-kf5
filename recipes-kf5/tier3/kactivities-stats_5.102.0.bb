# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kactivities-stats-5.102.0.tar.xz"
SRC_URI[sha256sum] = "107eed041618f5fdc1b78823880b70ef59c03513b8253835120088675ac6621b"

