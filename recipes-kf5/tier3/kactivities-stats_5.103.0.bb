# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kactivities-stats-5.103.0.tar.xz"
SRC_URI[sha256sum] = "f9e4106112c805fde8901b2e133f3ec757f6fad2d105be2aac8411c3920d453d"

