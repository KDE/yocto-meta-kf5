# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kactivities-stats-5.104.0.tar.xz"
SRC_URI[sha256sum] = "4e9e359fd16e790d5f4b6ea25727f610db98fbe51bf2d958d044d2bb349bba43"

