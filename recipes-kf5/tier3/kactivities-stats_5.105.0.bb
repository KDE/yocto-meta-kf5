# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kactivities-stats-5.105.0.tar.xz"
SRC_URI[sha256sum] = "ce513abd4715c2dd3ed7da699c6596dddc9cfb46526aed54c6399505ecad420a"

