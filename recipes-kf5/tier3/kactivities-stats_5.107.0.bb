# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kactivities-stats-5.107.0.tar.xz"
SRC_URI[sha256sum] = "678c424b2feb507908eb9b6e73dc5d8c6978dc22276d4169eabf4299eb64e1c2"

