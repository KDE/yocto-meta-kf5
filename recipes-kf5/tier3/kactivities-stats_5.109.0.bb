# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kactivities-stats-${PV}.tar.xz"
SRC_URI[sha256sum] = "dbd016c619035abce1c678fe237d273e1f961d6a969f4537212f5b397b32d270"

