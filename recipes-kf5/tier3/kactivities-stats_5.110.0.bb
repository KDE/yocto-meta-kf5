# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kactivities-stats-5.110.0.tar.xz"
SRC_URI[sha256sum] = "a47fc4501f5277666e53074f6b6d78c841f21a4eae119edefd99beba5ed3f8a9"

