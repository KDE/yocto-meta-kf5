# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kactivities-stats-5.83.0.tar.xz"
SRC_URI[sha256sum] = "22bf1f36180391fa5946a17dc2ea1cbcd34b2d28d0305edef86052fe07b52fd1"

