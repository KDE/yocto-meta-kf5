# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kactivities-stats-5.84.0.tar.xz"
SRC_URI[sha256sum] = "04ba923fc4d8a5ed94cf491fe89bb3e0921920f31de0d46c360a6ec6be0468d5"

