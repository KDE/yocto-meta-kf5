# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kactivities-stats-5.85.0.tar.xz"
SRC_URI[sha256sum] = "e19779787585fe26e0eec62c0f9ba7c8cf0c68b1c21eb43ee37d344d15e6c523"

