# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kactivities-stats-5.86.0.tar.xz"
SRC_URI[sha256sum] = "3047fa192dd9af3cca372bb176e4ba00719ee2c373b3accb41bb5ab9fd91949b"

