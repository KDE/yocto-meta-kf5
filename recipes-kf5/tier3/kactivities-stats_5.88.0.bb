# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kactivities-stats-5.88.0.tar.xz"
SRC_URI[sha256sum] = "2625a634bf5b5fdfe0ecf6d80777516b196503842f6657141c9bfd7a5c15119e"

