# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kactivities-stats-5.89.0.tar.xz"
SRC_URI[sha256sum] = "72a5b226133d48ecff6f0c06442ece0b1ace186c3081f62ff0aaa9a6e6dce3de"

