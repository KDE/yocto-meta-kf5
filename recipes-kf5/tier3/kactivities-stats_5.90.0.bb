# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kactivities-stats-5.90.0.tar.xz"
SRC_URI[sha256sum] = "772f475b4513df9e96179a8bf8767a305cf6945a7d9b3d2faa96caf73af25561"

