# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kactivities-stats-5.93.0.tar.xz"
SRC_URI[sha256sum] = "f1069872228e05aea349a0d3f7961da27d1aad3e4c28d0a408fceb98edef03a8"

