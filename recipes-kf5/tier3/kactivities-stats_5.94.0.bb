# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kactivities-stats-5.94.0.tar.xz"
SRC_URI[sha256sum] = "83fe7d109d830f348f18432949902700ee8a6a934cbaf3f89ae7bbfb28ef2340"

