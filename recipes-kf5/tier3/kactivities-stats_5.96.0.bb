# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kactivities-stats-5.96.0.tar.xz"
SRC_URI[sha256sum] = "da9c220a6cf7c8ec64db4cca1f642066f9c403c904bea3802efd9f55cab6ca51"

