# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kactivities-stats-5.97.0.tar.xz"
SRC_URI[sha256sum] = "e8a6c3b02dc9c3d9c250d44fa4b5a2e6c553bc8c0457e23ce7664274cdb88bdb"

