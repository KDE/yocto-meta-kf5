# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kactivities-stats-5.98.0.tar.xz"
SRC_URI[sha256sum] = "a8af6c60a1077dd0865b966839f49a8720a0a2e46acbd513e521391eea1c7c7f"

