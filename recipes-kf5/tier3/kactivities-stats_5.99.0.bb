# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kactivities-stats-5.99.0.tar.xz"
SRC_URI[sha256sum] = "933056fe0be56025f661cb37754d4f790cedf8615d6858b7fc63f31ca6d42033"

