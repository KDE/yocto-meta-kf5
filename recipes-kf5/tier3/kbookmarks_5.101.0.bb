# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kbookmarks-5.101.0.tar.xz"
SRC_URI[sha256sum] = "5d91617a36985af7b589fd6a43406067061667026578fdf3d20ac7b0f239702a"

