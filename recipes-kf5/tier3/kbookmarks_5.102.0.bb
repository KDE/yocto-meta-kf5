# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kbookmarks-5.102.0.tar.xz"
SRC_URI[sha256sum] = "9a9ee8dc87148649457f40e5f47055d66ec7168d27a8f8a19a6cb655ce4fe9c9"

