# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kbookmarks-5.103.0.tar.xz"
SRC_URI[sha256sum] = "1adf5480a939e4239db01962503c36b8c627715fb519be6703a647529eb1adac"

