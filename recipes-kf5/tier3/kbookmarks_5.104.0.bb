# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kbookmarks-5.104.0.tar.xz"
SRC_URI[sha256sum] = "85e565590233cfc6dc8c3459717c327961e79c74199d4d1c2741b40946936354"

