# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kbookmarks-5.105.0.tar.xz"
SRC_URI[sha256sum] = "cb0f625bef48d139f4207c9e18327ad0a64cbba66d312798b291b1090430a183"

