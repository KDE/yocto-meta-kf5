# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kbookmarks-5.107.0.tar.xz"
SRC_URI[sha256sum] = "50d1fad05c98c14970ef7fd4b12103bda5bf9a477d99b97f2e7acfeb641ced99"

