# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kbookmarks-${PV}.tar.xz"
SRC_URI[sha256sum] = "4d979b6b2504c80f2b4db7451ed82eac083d67641607146b9f897f3f04d01f06"

