# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kbookmarks-5.110.0.tar.xz"
SRC_URI[sha256sum] = "7013f696f643c3518f40041e4132edddf184c2c177bec231c16fecc81cab04cc"

