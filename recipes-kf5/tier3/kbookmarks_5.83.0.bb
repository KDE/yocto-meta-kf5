# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kbookmarks-5.83.0.tar.xz"
SRC_URI[sha256sum] = "550d2886f67108210d1a5b83511d315f4e836e092291f4ac6c15e67ee118e732"

