# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kbookmarks-5.84.0.tar.xz"
SRC_URI[sha256sum] = "ccbf74c3a281e7be60fadd08784a3be3c1e27f740fc0c3e7864396d2605575cc"

