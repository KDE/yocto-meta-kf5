# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kbookmarks-5.85.0.tar.xz"
SRC_URI[sha256sum] = "36130d9347beee614574ee7f6030279d1c425bbcdca759826a174026eb532a4b"

