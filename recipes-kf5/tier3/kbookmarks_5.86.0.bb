# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kbookmarks-5.86.0.tar.xz"
SRC_URI[sha256sum] = "500a1a750ee8222999e8d6cd8108f881fcd91bd109804d46bf31412b194906a8"

