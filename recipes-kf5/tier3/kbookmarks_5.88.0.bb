# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kbookmarks-5.88.0.tar.xz"
SRC_URI[sha256sum] = "82b0f2248a28417531edac66c14b1f1f75245b3887baa3663e0ebe707362428c"

