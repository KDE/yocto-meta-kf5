# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kbookmarks-5.89.0.tar.xz"
SRC_URI[sha256sum] = "d6eb01ae93738d105fd1227de4b4f3f5574bf516639bf21ff05cde1a552b7099"

