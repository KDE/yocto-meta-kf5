# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kbookmarks-5.93.0.tar.xz"
SRC_URI[sha256sum] = "3eeff795ff99be90b0d59c6e5fbef02022e9fb48c9b4dab098a3c27e10fd863f"

