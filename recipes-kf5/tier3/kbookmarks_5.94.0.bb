# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kbookmarks-5.94.0.tar.xz"
SRC_URI[sha256sum] = "8ccb99ab6f6e9babd503abd043ab183b849cfd9248d3b7d4e2805c75735f517c"

