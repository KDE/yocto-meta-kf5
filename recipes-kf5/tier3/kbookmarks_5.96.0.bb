# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kbookmarks-5.96.0.tar.xz"
SRC_URI[sha256sum] = "64a12cf0e16a3b457d89df4a327d0acae73c3030ef9918fa7036f7cad1b33e8c"

