# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kbookmarks-5.97.0.tar.xz"
SRC_URI[sha256sum] = "776dac6741d15dd02593891ad1b5d9ca3598df5edb3d431ed9e8c1386ae16b6a"

