# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kbookmarks-5.98.0.tar.xz"
SRC_URI[sha256sum] = "71e3ec3b5523656b0aa0089a8e8837e9823517654dde31c5e5625ddbc5c7f2e6"

