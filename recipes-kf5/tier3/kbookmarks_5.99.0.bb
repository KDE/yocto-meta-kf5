# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kbookmarks-5.99.0.tar.xz"
SRC_URI[sha256sum] = "b5b82d3fda366a2bcada2500ee7f727c1eda0c4218330511ae58993893c1686d"

