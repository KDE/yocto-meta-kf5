# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kcmutils-5.101.0.tar.xz"
SRC_URI[sha256sum] = "ab4f18a5616d2ebd4c4ea14fb82c74cfa8adb0e904dd5602eca48ad7a143c54b"

