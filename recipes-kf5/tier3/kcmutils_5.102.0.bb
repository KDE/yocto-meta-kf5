# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kcmutils-5.102.0.tar.xz"
SRC_URI[sha256sum] = "b2439f8530cae160dac6fc751d9d9d552299f8ad8442ef20f69605afaefb3aba"

