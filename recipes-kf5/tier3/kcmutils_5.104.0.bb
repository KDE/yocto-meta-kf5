# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kcmutils-5.104.0.tar.xz"
SRC_URI[sha256sum] = "754b1588d0444522f26b420af74cd425410099614a5ffd9c45e6405251d1168a"

