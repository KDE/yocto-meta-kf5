# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kcmutils-5.105.0.tar.xz"
SRC_URI[sha256sum] = "2e37e437e547a24beca24546aa2bf76f13b43f762e5f43960d0cd6f5d89b2929"

