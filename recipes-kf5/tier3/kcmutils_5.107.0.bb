# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kcmutils-5.107.0.tar.xz"
SRC_URI[sha256sum] = "4698d6ccdbfb1a58103b5e23f330c0aa3cf265e78f5a1f0ba9c88dd8bf8850d5"

