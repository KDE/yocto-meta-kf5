# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kcmutils-${PV}.tar.xz"
SRC_URI[sha256sum] = "009e6b9b006583325b0440d1ece10e7296bc7e461c4bf14d9b362dfa55010b46"

