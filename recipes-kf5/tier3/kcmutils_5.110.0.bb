# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kcmutils-5.110.0.tar.xz"
SRC_URI[sha256sum] = "58fd9b69052cdb585d1e226013c69d311abc7dd2814bb52d4888f3534ecb8f31"

