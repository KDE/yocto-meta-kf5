# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kcmutils-5.84.0.tar.xz"
SRC_URI[sha256sum] = "eea7052e1424680d417981036d463916e2bdc55164a7161fa2d276f1348b93a9"

