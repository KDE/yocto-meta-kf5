# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kcmutils-5.85.0.tar.xz"
SRC_URI[sha256sum] = "20e8a32f1f22bc0afc682b694c2d6d8333c9de796845904685269fb3719ece93"

