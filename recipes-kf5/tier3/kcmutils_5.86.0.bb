# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kcmutils-5.86.0.tar.xz"
SRC_URI[sha256sum] = "a88797e60401a3524752df1bf5205a4bafac5d826e26df2c4d691fcd33e4ca4c"

