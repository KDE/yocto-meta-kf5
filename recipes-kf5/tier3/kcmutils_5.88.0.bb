# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kcmutils-5.88.0.tar.xz"
SRC_URI[sha256sum] = "008a2348c35b29f9257c99d0e68343a168e799adcf83eaa13ca6324db47e193f"

