# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kcmutils-5.89.0.tar.xz"
SRC_URI[sha256sum] = "15fe79b0d38bf5af298ede402f9c928ea7a05a5ddcdcf8c28a9e5b9a36ea497d"

