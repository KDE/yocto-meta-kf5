# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kcmutils-5.90.0.tar.xz"
SRC_URI[sha256sum] = "b36300a5f400e082b800508292c2d6e5bdb033567cdc43c0dd947744e4c09911"

