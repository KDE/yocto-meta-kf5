# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kcmutils-5.93.0.tar.xz"
SRC_URI[sha256sum] = "1445f978b7ffd69fd7c25d965812755679c4fdba23eb9837da37a8b5b2d30d6d"

