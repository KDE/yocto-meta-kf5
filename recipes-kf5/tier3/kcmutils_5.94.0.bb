# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kcmutils-5.94.0.tar.xz"
SRC_URI[sha256sum] = "798cef6990cdcb22e4822ea12c3c0b9aa35797806e93fb474a2f58632cd53309"

