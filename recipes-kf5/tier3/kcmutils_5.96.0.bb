# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kcmutils-5.96.0.tar.xz"
SRC_URI[sha256sum] = "88819fe343776a1819eecddbe2caa936ea2e9fbbfd2a155c46b82525e748ce6d"

