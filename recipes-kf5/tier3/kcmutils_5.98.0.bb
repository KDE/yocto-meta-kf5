# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kcmutils-5.98.0.tar.xz"
SRC_URI[sha256sum] = "1d1740f3a115111802fcd58c3f7c3e52ca77f65e2c449859ccdd4a132279134b"

