# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kconfigwidgets-5.101.0.tar.xz"
SRC_URI[sha256sum] = "012b5a49bc1a39387f9fdb3a23f21e6669f146577942aa74cbbf4213e18578a8"

