# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kconfigwidgets-5.102.0.tar.xz"
SRC_URI[sha256sum] = "d76458119bb738493f04b88d5f9eb00a03dec0a1cfc1ef3b21db1c4e9b177aa7"

