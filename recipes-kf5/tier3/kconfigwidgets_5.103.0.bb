# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kconfigwidgets-5.103.0.tar.xz"
SRC_URI[sha256sum] = "f91cef38cc4e6068a35ad36a1ad229e2f57821dab22b4cc6181df671f16aa373"

