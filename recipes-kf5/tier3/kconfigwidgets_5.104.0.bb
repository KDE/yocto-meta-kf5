# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kconfigwidgets-5.104.0.tar.xz"
SRC_URI[sha256sum] = "eb9014b813a1c8a18c78ef11be296964b31338e5237080a74234bf97ead64522"

