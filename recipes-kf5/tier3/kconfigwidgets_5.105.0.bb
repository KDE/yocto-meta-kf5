# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kconfigwidgets-5.105.0.tar.xz"
SRC_URI[sha256sum] = "068f4d3810a07dcc7b69115584d7948e9252b4bb3fc381ec48b71798e2c4d94a"

