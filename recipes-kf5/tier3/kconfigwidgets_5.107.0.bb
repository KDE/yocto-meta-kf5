# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kconfigwidgets-5.107.0.tar.xz"
SRC_URI[sha256sum] = "f16d8578ab311b46bdbdac11beaeca6b70a19417622d70c7b07fb6d71545c068"

