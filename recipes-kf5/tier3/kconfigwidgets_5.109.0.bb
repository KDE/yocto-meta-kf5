# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kconfigwidgets-${PV}.tar.xz"
SRC_URI[sha256sum] = "1e67fa94fd1a91ceb7800061b80e7a498d8031b75d8baabe1099e9e62cd614bf"

