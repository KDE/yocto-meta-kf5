# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kconfigwidgets-5.110.0.tar.xz"
SRC_URI[sha256sum] = "4f0fc941bae4eb41436a2b5dbc45bf3116268f7e98b15aedc347dfd603e1b412"

