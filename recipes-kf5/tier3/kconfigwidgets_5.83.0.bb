# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kconfigwidgets-5.83.0.tar.xz"
SRC_URI[sha256sum] = "d73260735be071fa6a1893ad6498d1ead1288a81bfb9a0b26d085cf7defd40c3"

