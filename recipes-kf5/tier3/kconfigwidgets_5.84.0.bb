# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kconfigwidgets-5.84.0.tar.xz"
SRC_URI[sha256sum] = "36ea5e2263776f988a9b2301f4605ccb4b3683afbe770c1896a5525e12711e9e"

