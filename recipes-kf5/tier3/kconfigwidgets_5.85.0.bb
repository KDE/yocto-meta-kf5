# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kconfigwidgets-5.85.0.tar.xz"
SRC_URI[sha256sum] = "79efd392d025c3cedbd24a7b0d336e50f5026a514312e862d61c8dc65a70a843"

