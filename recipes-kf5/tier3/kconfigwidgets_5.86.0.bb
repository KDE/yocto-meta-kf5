# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kconfigwidgets-5.86.0.tar.xz"
SRC_URI[sha256sum] = "e64c07ea6b8786365fd4ac174f9b29d1c3da58329184c27909c81c281c33044d"

