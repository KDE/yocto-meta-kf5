# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kconfigwidgets-5.88.0.tar.xz"
SRC_URI[sha256sum] = "7995523bee2c89867287a26994859ceb7d2a5be80e7bce80c186d6339bf18ad4"

