# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kconfigwidgets-5.89.0.tar.xz"
SRC_URI[sha256sum] = "c0341b991e9dab65bd8f9e6236d49b15365c780b8beae8a5116c2166a7e8f867"

