# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kconfigwidgets-5.93.0.tar.xz"
SRC_URI[sha256sum] = "db18e0f2217ead6dd6f5877551902d5da86aa026686e3c564f5f96be279f24bb"

