# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kconfigwidgets-5.94.0.tar.xz"
SRC_URI[sha256sum] = "35055f637ff44b0f0e67f9b5c79307d37f5c259289bf71b2a24c0203f82fb508"

