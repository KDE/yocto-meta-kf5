# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kconfigwidgets-5.96.0.tar.xz"
SRC_URI[sha256sum] = "1482f42562be8db93c9161acf2b24fa839f05bc893f22f02a3c1e972e733b210"

