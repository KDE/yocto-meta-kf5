# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kconfigwidgets-5.97.0.tar.xz"
SRC_URI[sha256sum] = "20c6016c06a0d24a97af5cd36ed319eee918af051a62265f3f51c7c1c6c58428"

