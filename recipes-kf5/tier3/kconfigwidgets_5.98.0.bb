# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kconfigwidgets-5.98.0.tar.xz"
SRC_URI[sha256sum] = "eb3420af0bab13f1a55fac3c796005d140a68b29c52fd9f5a7cdccc270a37c15"

