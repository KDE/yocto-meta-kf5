# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kconfigwidgets-5.99.0.tar.xz"
SRC_URI[sha256sum] = "8579be2a4301071fb0485fccc733083b58330ac92d776be1b73e6f377a7dbf1f"

