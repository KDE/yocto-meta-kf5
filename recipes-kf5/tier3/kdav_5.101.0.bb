# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kdav-5.101.0.tar.xz"
SRC_URI[sha256sum] = "3c084a69a913d2bb34eaed2fdeeefb1c671fab82999dfb5e13d387c36301013f"

