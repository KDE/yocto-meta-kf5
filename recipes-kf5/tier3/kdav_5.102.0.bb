# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kdav-5.102.0.tar.xz"
SRC_URI[sha256sum] = "6e057242e225cfd68d1afb6fa7368d5cc51ed4997fa63bb7f50cd6b3eb11395f"

