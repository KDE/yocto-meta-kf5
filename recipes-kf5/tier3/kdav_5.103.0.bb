# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kdav-5.103.0.tar.xz"
SRC_URI[sha256sum] = "34a2189d70825f735ade55e2bfa5518c482abefd0c2979f737ce581397b6a166"

