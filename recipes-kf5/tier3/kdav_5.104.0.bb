# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kdav-5.104.0.tar.xz"
SRC_URI[sha256sum] = "6f897ba8415f444aa1e58b9538da529c710337089fd33fb0104e73da95165c71"

