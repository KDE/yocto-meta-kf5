# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kdav-5.105.0.tar.xz"
SRC_URI[sha256sum] = "3de27547f16a32074387e049c17da94b13d82b0f5f86fb6abf06100a828be335"

