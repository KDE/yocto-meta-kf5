# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kdav-5.107.0.tar.xz"
SRC_URI[sha256sum] = "579da54db79d360e17c500c62a9ada81cdf5db84a40799f98f2f7cbac70a9b6f"

