# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kdav-${PV}.tar.xz"
SRC_URI[sha256sum] = "c8b69d20ba2794ad5157e0ed4ffb710b13026700af32f5f62190e8966a901620"

