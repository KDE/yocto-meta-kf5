# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kdav-5.110.0.tar.xz"
SRC_URI[sha256sum] = "ca748facfcf92a993da5c01ebdb3b7db0096fb3cb071c2cf0f7387e8128ee563"

