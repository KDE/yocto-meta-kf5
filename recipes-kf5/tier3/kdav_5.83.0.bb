# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kdav-5.83.0.tar.xz"
SRC_URI[sha256sum] = "0017138873ba67a724ffc04d5f098a8a3b98c6b708ea10d2ff3de0efa33fa039"

