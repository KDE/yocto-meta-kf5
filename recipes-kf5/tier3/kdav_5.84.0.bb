# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kdav-5.84.0.tar.xz"
SRC_URI[sha256sum] = "d81487836bb381da13bfb096e53f3a2e9c4eafb3e948a8de58065d76c2f19427"

