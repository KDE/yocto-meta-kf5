# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kdav-5.85.0.tar.xz"
SRC_URI[sha256sum] = "54035580be838237acac5e3c132f52293d4876640abfbfc23ade8196c26e9c87"

