# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kdav-5.86.0.tar.xz"
SRC_URI[sha256sum] = "c3e5561f152cf8dcd47e30b7a03c292e8fba7fb4220c8a3d6e27709b4e5dfef2"

