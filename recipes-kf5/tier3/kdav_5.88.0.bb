# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kdav-5.88.0.tar.xz"
SRC_URI[sha256sum] = "7cf87774f0d1b9437b113ba0e2495d253d5cd73769c2b2e160a7d3859e3ff2c7"

