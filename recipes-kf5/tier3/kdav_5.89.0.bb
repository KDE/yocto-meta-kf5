# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kdav-5.89.0.tar.xz"
SRC_URI[sha256sum] = "db288d98656840115e96e713aa49e75801d02338d87840a6d52187ebfa32cff3"

