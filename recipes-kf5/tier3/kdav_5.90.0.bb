# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kdav-5.90.0.tar.xz"
SRC_URI[sha256sum] = "71bdde6d2a3361c949f7b39844c9035481c06d6c45925e15e5f5c58dbcca0105"

