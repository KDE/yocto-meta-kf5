# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kdav-5.93.0.tar.xz"
SRC_URI[sha256sum] = "a7d3d40120f0a1b20f8492ea1635507a95e041582f5496a133de24720934ad68"

