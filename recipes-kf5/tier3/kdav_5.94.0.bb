# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kdav-5.94.0.tar.xz"
SRC_URI[sha256sum] = "8b211ec6e1009f11ae5d0769e21947a473d6ca479ea8a16701a808aa57335b3e"

