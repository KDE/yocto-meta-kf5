# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kdav-5.96.0.tar.xz"
SRC_URI[sha256sum] = "94872e54c483ddf02d220b074285f979ad634f85a4c3fa8854e93952275a11ff"

