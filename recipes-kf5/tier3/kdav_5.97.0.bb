# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kdav-5.97.0.tar.xz"
SRC_URI[sha256sum] = "d58d8435eef1f57f0e7d207d63e002e29e0067e2621c522dfcba6f5df4fca5db"

