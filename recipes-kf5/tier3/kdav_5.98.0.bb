# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kdav-5.98.0.tar.xz"
SRC_URI[sha256sum] = "f137a1fbe9acd29ef0dc320c233c42162a46a8a976f5a5c3b20ffb3387228708"

