# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kdav-5.99.0.tar.xz"
SRC_URI[sha256sum] = "edf3e811f24205294973e495731bce7e8f0bfdfc84c284cdbcc572be3cb566e4"

