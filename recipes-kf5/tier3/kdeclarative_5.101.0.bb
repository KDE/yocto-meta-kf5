# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kdeclarative-5.101.0.tar.xz"
SRC_URI[sha256sum] = "2a208f5af8c83db3979ed28e9a9aa3a80c709a3c08612fbf77792cd314afe476"

