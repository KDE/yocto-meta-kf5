# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kdeclarative-5.102.0.tar.xz"
SRC_URI[sha256sum] = "0ad46234d48034da8c195fececf66392e876c61ad0a328f4ea91c72d6bc87c77"

