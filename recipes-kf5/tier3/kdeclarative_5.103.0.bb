# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kdeclarative-5.103.0.tar.xz"
SRC_URI[sha256sum] = "b6ca5cfb000cd1ed10af6884152fb21b5f8e9fb1041c53c36244435265ffb252"

