# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kdeclarative-5.104.0.tar.xz"
SRC_URI[sha256sum] = "82a794bd7e2148b05f203d032bee1cbf08a8364872f7eef31adc73e48cede6c0"

