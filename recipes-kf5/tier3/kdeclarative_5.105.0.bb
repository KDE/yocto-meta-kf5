# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kdeclarative-5.105.0.tar.xz"
SRC_URI[sha256sum] = "44ce2dc69f9bc93f5a039cb14f3043e4a9d98fbed5e031bf8d6fd6778b958ae4"

