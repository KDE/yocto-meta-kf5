# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kdeclarative-5.107.0.tar.xz"
SRC_URI[sha256sum] = "df50ed868176fc2b138ac2a24148de7d73165ebe1cfd4f3740953069ce880855"

