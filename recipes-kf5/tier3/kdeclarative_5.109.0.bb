# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kdeclarative-${PV}.tar.xz"
SRC_URI[sha256sum] = "a22545bb2e6c2f72a60e9260bec9aecafd8637d779070527b4be52cf4b1137e3"

