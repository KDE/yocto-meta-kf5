# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kdeclarative-5.110.0.tar.xz"
SRC_URI[sha256sum] = "525ac4f4754680f86d70382af3c0cf3c9bc8cf0b57d0b84be5274549496c98ed"

