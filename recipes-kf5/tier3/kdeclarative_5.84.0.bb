# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kdeclarative-5.84.0.tar.xz"
SRC_URI[sha256sum] = "26c7cea97973c242a34d511f8e41b1cebcfdbb864cce7570ec513af0b91cf779"

