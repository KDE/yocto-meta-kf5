# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kdeclarative-5.85.0.tar.xz"
SRC_URI[sha256sum] = "4de6001bb6cda802e1e7aee2a7254fa254ffdd38cb423344b2308108badbabe1"

