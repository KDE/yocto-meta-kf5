# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kdeclarative-5.86.0.tar.xz"
SRC_URI[sha256sum] = "2dc9ace34de78e4eb78d6132578126b25cc67dce63c5f3adb535355f2335edb4"

