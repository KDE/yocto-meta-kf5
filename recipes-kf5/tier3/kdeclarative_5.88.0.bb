# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kdeclarative-5.88.0.tar.xz"
SRC_URI[sha256sum] = "b506b44b9f50768de9b145980a41de943c2b375defc7e5a97fbb9fc2a441e3a9"

