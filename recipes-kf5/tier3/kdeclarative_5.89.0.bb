# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kdeclarative-5.89.0.tar.xz"
SRC_URI[sha256sum] = "5ee99a4b058cb5931b314b832e9c7d900e67081519ae741a21b240603acb44a1"

