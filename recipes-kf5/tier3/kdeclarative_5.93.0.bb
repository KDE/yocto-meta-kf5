# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kdeclarative-5.93.0.tar.xz"
SRC_URI[sha256sum] = "08a945c793aa8d89d87c42d29c9c11e7c28c47916ae728369ab478892d325067"

