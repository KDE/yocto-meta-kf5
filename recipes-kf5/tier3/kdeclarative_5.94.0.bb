# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kdeclarative-5.94.0.tar.xz"
SRC_URI[sha256sum] = "f2996ca7671994f42c9233897d10d6bc93ffc2b12865ae07e516a93812dd6b08"

