# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kdeclarative-5.97.0.tar.xz"
SRC_URI[sha256sum] = "be68d2983643616e257d7a4cc07f87e5e2219abc3ce9cf5500e0fc9e46185a70"

