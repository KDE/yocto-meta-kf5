# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kdeclarative-5.98.0.tar.xz"
SRC_URI[sha256sum] = "0672c0b57be19d1efa2b208f9836e2f0c1f67a2aab39d3cff29bc36f5965ba78"

