# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kdeclarative-5.99.0.tar.xz"
SRC_URI[sha256sum] = "168acc11b96a0f47dc7458390d31bb46f5fdd7337488ab18a60bfc0368113aa4"

