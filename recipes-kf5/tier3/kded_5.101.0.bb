# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kded-5.101.0.tar.xz"
SRC_URI[sha256sum] = "e89c831e68815d3c68d40ab7d0e660935c684e322232b24b687781b42bbb2ee9"

