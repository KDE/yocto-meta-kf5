# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kded-5.102.0.tar.xz"
SRC_URI[sha256sum] = "6775af55a7888bc636f546cb3d0c25890dc7f6b2ab25bab90c29c7fb785a563a"

