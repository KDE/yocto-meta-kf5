# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kded-5.103.0.tar.xz"
SRC_URI[sha256sum] = "00a760becee15f782ef05c26be212565df4d718c7a81ec35e143d31cdac8948d"

