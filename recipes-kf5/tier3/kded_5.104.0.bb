# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kded-5.104.0.tar.xz"
SRC_URI[sha256sum] = "2785972032c44e5d72c5643f6a5a9925e1fbf5389eb2ec00bd9d9d90a77ac4af"

