# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kded-5.105.0.tar.xz"
SRC_URI[sha256sum] = "ac588d6ee850ce60b5128043617c6986cd04122e792052b1d515c4343ed851fb"

