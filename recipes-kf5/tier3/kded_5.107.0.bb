# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kded-5.107.0.tar.xz"
SRC_URI[sha256sum] = "cf2f08cfc411bb6b2a60906999fe94bddd8df4a9497e8d37cfb62399e6e8b73b"

