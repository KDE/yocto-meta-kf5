# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kded-${PV}.tar.xz"
SRC_URI[sha256sum] = "3e3b5d7d123a1c7b627138803ef7ddc228eff23ae9053909283aec5c9c306293"

