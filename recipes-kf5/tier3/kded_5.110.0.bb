# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kded-5.110.0.tar.xz"
SRC_URI[sha256sum] = "d4bfecd640bed1abdcbd5008e505ba8cea1f807ad362a8ceaaa4670cf9fc10d9"

