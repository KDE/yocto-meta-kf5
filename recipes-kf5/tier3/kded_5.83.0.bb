# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kded-5.83.0.tar.xz"
SRC_URI[sha256sum] = "69319e6bc587c1089ee46fc8933484790a816355909df2830721b25911a09b3b"

