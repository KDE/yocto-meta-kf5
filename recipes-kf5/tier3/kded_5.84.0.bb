# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kded-5.84.0.tar.xz"
SRC_URI[sha256sum] = "4c96159e2f0255e4cefbfb671ac37d489bb70031536f098f3bc5f70559a6d330"

