# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kded-5.85.0.tar.xz"
SRC_URI[sha256sum] = "3c361952918e4f887a7db0ab202525488871ad8e4ea33715040ce89cd94f59f9"

