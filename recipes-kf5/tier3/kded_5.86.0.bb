# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kded-5.86.0.tar.xz"
SRC_URI[sha256sum] = "dc77534c1612b1232bcc52431bbdc8a4a46b095c90ba60c09a01e6404118a36a"

