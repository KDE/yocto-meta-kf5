# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kded-5.88.0.tar.xz"
SRC_URI[sha256sum] = "cc240053ad396821a8b7174f44ce41a9db793ad3c6dda4ad8d84fd4994b794e1"

