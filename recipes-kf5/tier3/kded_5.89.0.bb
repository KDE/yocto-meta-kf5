# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kded-5.89.0.tar.xz"
SRC_URI[sha256sum] = "d42d189098c30b7fdf0fcd5f37153d4671b121a450ccd38e449d7e60d67923e7"

