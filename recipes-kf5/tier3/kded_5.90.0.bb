# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kded-5.90.0.tar.xz"
SRC_URI[sha256sum] = "faea3349e15c9c671c33172020787cb2e76f7809231c9d15ebac347bd0358f24"

