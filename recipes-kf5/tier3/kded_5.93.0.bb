# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kded-5.93.0.tar.xz"
SRC_URI[sha256sum] = "1992310921cccaf8fa2ca1abc8328aec5bc2e60a3d9f562f25b30885378159df"

