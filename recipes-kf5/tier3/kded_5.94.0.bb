# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kded-5.94.0.tar.xz"
SRC_URI[sha256sum] = "2f4d61a3e8c64f81e5916558d48e381d0a3890c5ad388f27934944136c44f3c5"

