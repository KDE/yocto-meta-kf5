# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kded-5.96.0.tar.xz"
SRC_URI[sha256sum] = "63bdf191aade3b02261b30c8a5e7f6ab9d3f6c765b4cffec254b3ed1d9f68074"

