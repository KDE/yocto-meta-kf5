# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kded-5.98.0.tar.xz"
SRC_URI[sha256sum] = "e5b47670442798dfb1b4a771d6e4be30cc12b730add2c3ab6c7b3b186deb1ecd"

