# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kdesu-5.101.0.tar.xz"
SRC_URI[sha256sum] = "f1abff4b7e7767216958f061553b73dd4003ef2b560f73e4e5a82f410c02e599"

