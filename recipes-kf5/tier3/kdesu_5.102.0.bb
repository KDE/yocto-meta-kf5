# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kdesu-5.102.0.tar.xz"
SRC_URI[sha256sum] = "d0a93372bba338eed98940c3495bada9426f2737485a7231e1f7a9bf7746485f"

