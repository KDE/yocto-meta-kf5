# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kdesu-5.103.0.tar.xz"
SRC_URI[sha256sum] = "118ace7a5198cd9f5a585fbc82d4482b513f1f15a666b0116ee6d0159aadaba6"

