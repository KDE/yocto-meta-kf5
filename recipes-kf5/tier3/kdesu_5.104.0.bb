# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kdesu-5.104.0.tar.xz"
SRC_URI[sha256sum] = "219eeb1f6b6881f04af71e557c6dcc43f0731c128f4e1596aac0d6fd098b6eb2"

