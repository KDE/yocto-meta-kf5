# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kdesu-5.105.0.tar.xz"
SRC_URI[sha256sum] = "12a64ddb93c30ec299befd23e9c32eae340437ea3d97d18a21865778de078655"

