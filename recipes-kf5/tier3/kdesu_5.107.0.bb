# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kdesu-5.107.0.tar.xz"
SRC_URI[sha256sum] = "7d1017e508561e66af1fd2df32b340696d64f48b86a98d085a2e47ac0352158a"

