# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kdesu-5.110.0.tar.xz"
SRC_URI[sha256sum] = "29671f196e3881307d44d12654b2f86ec6af31f053f062065b64077b29998552"

