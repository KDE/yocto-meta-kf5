# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kdesu-5.83.0.tar.xz"
SRC_URI[sha256sum] = "9eefd9bf9d77f2af58774adea4c9f875472b03ea7e5064e68e901420d2b41fe3"

