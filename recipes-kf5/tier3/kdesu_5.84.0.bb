# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kdesu-5.84.0.tar.xz"
SRC_URI[sha256sum] = "2d752997389a57ee7f088c205ce225c5449fe574e061fab1672c33832496742c"

