# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kdesu-5.85.0.tar.xz"
SRC_URI[sha256sum] = "08b4b25b956db0a9e0c5b712d19220aaa8433d29702e85d5c8f451979a9f1ff7"

