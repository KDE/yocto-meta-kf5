# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kdesu-5.86.0.tar.xz"
SRC_URI[sha256sum] = "88f6f6eae168dde81d52255c1fb80178ae101c6840892bea644137fac18bb521"

