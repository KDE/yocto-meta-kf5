# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kdesu-5.89.0.tar.xz"
SRC_URI[sha256sum] = "3d57a03fe232ca81ffcf2fc559114950ff58648474f298dd65091c4343e0bc4a"

