# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kdesu-5.90.0.tar.xz"
SRC_URI[sha256sum] = "970707b7717d8a3c38687f40ff93809b3779e527d8a6ce5fe2df05c20e1613e1"

