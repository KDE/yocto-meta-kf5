# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kdesu-5.93.0.tar.xz"
SRC_URI[sha256sum] = "7f029d9a8959f0e2ca516ab3fb6b4ebd49ca0f0d19c72369451b6894d8138dbf"

