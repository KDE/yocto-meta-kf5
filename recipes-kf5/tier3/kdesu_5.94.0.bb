# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kdesu-5.94.0.tar.xz"
SRC_URI[sha256sum] = "90494323ebab4c8cdd93c068c2c4fe3a8457513cee21d7887fc4473028a9dce1"

