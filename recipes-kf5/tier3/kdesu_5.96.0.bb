# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kdesu-5.96.0.tar.xz"
SRC_URI[sha256sum] = "72437597e32d19f170d1441c607e353ccbd125fe6608d041e8fa64e92e9752f2"

