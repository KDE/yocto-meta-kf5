# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kdesu-5.97.0.tar.xz"
SRC_URI[sha256sum] = "652eb62f3a1f5600b15b1e42ff4d2542ccc9786244b58b73baa4511964d64fb3"

