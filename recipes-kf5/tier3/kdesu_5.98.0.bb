# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kdesu-5.98.0.tar.xz"
SRC_URI[sha256sum] = "629fe9bce7c106a6ad9379fd0174e518a0f5b74e1ae2cda985944c17ff59cb95"

