# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kdesu-5.99.0.tar.xz"
SRC_URI[sha256sum] = "b393d9de503c2785eb20fe88b21983abf6917e1079b2b2d77341cd6255751c32"

