# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kemoticons-5.101.0.tar.xz"
SRC_URI[sha256sum] = "1caeda91e53ff8d24ea08a379c6f12060cfa7bf9a93293b43a97d77175bf7a72"

