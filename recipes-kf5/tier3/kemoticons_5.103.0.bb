# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kemoticons-5.103.0.tar.xz"
SRC_URI[sha256sum] = "13c1c2213868022ea38fa7612282d443e1461425aec42c5a91766f5f035ffa82"

