# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kemoticons-5.104.0.tar.xz"
SRC_URI[sha256sum] = "ce61f3a905d84206e622b76954a05be4eea1e9ad012c3d0b694e1fe7af94c2e0"

