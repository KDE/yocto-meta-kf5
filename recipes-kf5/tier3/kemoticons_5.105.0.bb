# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kemoticons-5.105.0.tar.xz"
SRC_URI[sha256sum] = "c028b73b2970cfaeef1c9fff2826eed92cd8dac1870f70d96e541f36dac54644"

