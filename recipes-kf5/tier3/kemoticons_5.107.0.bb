# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kemoticons-5.107.0.tar.xz"
SRC_URI[sha256sum] = "56f8748232d08527e535cc678d30241033c20c14141a027b2915aee551953e4c"

