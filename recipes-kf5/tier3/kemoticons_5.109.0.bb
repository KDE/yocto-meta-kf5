# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kemoticons-${PV}.tar.xz"
SRC_URI[sha256sum] = "f0a21dd4b621f2312d3778655e782c2e7a727f6e3e87bcc9ced01a8bfc32c86b"

