# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kemoticons-5.110.0.tar.xz"
SRC_URI[sha256sum] = "22f80fae0c356128d30f2eeda333a9d53298966091789ef01c867f6ef81c2de4"

