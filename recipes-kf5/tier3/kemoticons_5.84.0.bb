# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kemoticons-5.84.0.tar.xz"
SRC_URI[sha256sum] = "0733fe001a6257256326969e4e857e26883a03c2132794775d15f9d2f8a31141"

