# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kemoticons-5.85.0.tar.xz"
SRC_URI[sha256sum] = "5ce7c97b7d50560adc069c08eecf0925df2ceb53e15804ae241851ec0088307e"

