# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kemoticons-5.86.0.tar.xz"
SRC_URI[sha256sum] = "ad2729ef49fd18a0d743e4137d9033246b1b3ffc599d219d768c6bb54ba7cf52"

