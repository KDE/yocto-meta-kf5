# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kemoticons-5.88.0.tar.xz"
SRC_URI[sha256sum] = "0ed955801d4185aaadfebaf54bcb263d701d10bc89b3dccbf689bb516caf34cd"

