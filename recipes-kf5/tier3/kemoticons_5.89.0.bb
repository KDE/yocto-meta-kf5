# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kemoticons-5.89.0.tar.xz"
SRC_URI[sha256sum] = "fc6369978ce873a19c6fc9172fbfb24d5dfc25c21c42cea11ca71bc580c09e55"

