# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kemoticons-5.90.0.tar.xz"
SRC_URI[sha256sum] = "8b191c0a06faa34bc8fb37cbe922d28530874fe80c27a35fc2433ad54c99af22"

