# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kemoticons-5.93.0.tar.xz"
SRC_URI[sha256sum] = "83ca3df374935cf103a8fdaa85900d0acadbffc9d3aa8bfed073e804cd5ae410"

