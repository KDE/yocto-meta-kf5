# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kemoticons-5.94.0.tar.xz"
SRC_URI[sha256sum] = "fa7db15d75a017e75514af4361ae3dd91a22ac9d9e2daf41a8e7e33bcce31302"

