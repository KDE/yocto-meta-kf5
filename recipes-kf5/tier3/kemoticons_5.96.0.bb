# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kemoticons-5.96.0.tar.xz"
SRC_URI[sha256sum] = "e5b823df8ea2e350877e652075830f17464600345b06ba66e05e99b67957650d"

