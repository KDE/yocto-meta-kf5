# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kemoticons-5.97.0.tar.xz"
SRC_URI[sha256sum] = "e25afceabb2cd35ae6f38b9e2d40c88d6ec20077b700971cec08147a6041310a"

