# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kemoticons-5.98.0.tar.xz"
SRC_URI[sha256sum] = "0276363b5d0bb45f2f2a93b44ef36b2e0f9154fb722f5d929579627bab046d38"

