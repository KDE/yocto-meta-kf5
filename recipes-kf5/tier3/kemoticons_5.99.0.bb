# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kemoticons-5.99.0.tar.xz"
SRC_URI[sha256sum] = "da6b220402c39636552aacb5f6c5cef667de6eab335aaedd218cc5c4c9d530ba"

