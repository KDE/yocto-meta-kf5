# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kglobalaccel-5.101.0.tar.xz"
SRC_URI[sha256sum] = "3203222ca86b15e73f9da1fde572a1374c3a8353ed2608c2160e1973c57a6062"

