# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kglobalaccel-5.102.0.tar.xz"
SRC_URI[sha256sum] = "b5a9dd1ed9df5af3be2af90981b2ab7a7dc3034f133b61360eab7191c29955d0"

