# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kglobalaccel-5.104.0.tar.xz"
SRC_URI[sha256sum] = "d9d2f89540b4d399b9af19afb69f53bb9efffb87471f636bb83839767aba7eae"

