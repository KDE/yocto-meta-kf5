# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kglobalaccel-5.105.0.tar.xz"
SRC_URI[sha256sum] = "a8b0f8d6857d86d47fa64ac9853b8d397e6c7bea39dda8b5d99a61cd5dfba494"

