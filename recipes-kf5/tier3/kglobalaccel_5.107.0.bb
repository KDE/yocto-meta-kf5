# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kglobalaccel-5.107.0.tar.xz"
SRC_URI[sha256sum] = "a874824335b811ce1ad7b08f37e0ae992e813ea2fad34de252ea8e9239349ed8"

