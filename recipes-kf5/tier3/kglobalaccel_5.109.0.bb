# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kglobalaccel-${PV}.tar.xz"
SRC_URI[sha256sum] = "a58e5ea7b3628f4d56cbe493915136aeb1d7606e30b53442441892bae2d1a9e2"

