# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kglobalaccel-5.110.0.tar.xz"
SRC_URI[sha256sum] = "f75325f5f7b9e6d254e82c58ec4395091514d1759b050235fbf78099fd1682c7"

