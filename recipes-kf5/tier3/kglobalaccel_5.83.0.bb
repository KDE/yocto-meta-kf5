# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kglobalaccel-5.83.0.tar.xz"
SRC_URI[sha256sum] = "b405e6bbee16169741cf18929998c0c8e4970573add8661b5373d72f2130affe"

