# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kglobalaccel-5.84.0.tar.xz"
SRC_URI[sha256sum] = "658e7e955606335372e1413c53db2102ba4207f189ad2b4fe3b4906bfa27726c"

