# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kglobalaccel-5.86.0.tar.xz"
SRC_URI[sha256sum] = "92c17c821143d7314264446c9df7596dad29c51c79ab6596280103e8ba61c172"

