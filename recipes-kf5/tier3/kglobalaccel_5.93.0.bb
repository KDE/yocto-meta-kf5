# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kglobalaccel-5.93.0.tar.xz"
SRC_URI[sha256sum] = "c806b8f2b029c7632d99c55cb711f9f4c1697555fde53ad4f67167efee97b712"

