# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kglobalaccel-5.94.0.tar.xz"
SRC_URI[sha256sum] = "a34b00116a72d0973cdeb203a5d237da63cc307e9e294dfaedb00ff0a36835e9"

