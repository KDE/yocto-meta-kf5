# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kglobalaccel-5.96.0.tar.xz"
SRC_URI[sha256sum] = "388ad7d490ba91c3bbf04e73312d9482bfdc6beb80b711418d42f88e7c75a4eb"

