# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kglobalaccel-5.98.0.tar.xz"
SRC_URI[sha256sum] = "949d71f6359da0927d1f95d7f57ab14a5d871be3a251606c34aaeb7ee99926ef"

