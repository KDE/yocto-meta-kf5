# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kglobalaccel-5.99.0.tar.xz"
SRC_URI[sha256sum] = "471d7ded850440716659e93e790a237b4aa4e30a4e04a937e764a87ca7899c30"

