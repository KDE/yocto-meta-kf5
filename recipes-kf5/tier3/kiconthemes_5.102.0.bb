# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kiconthemes-5.102.0.tar.xz"
SRC_URI[sha256sum] = "d0cf5efcbe8cadd5176293b549f32640a155162a9d7c96d2246315bb8f8c2ee0"

