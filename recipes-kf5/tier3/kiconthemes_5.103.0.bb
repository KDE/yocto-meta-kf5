# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kiconthemes-5.103.0.tar.xz"
SRC_URI[sha256sum] = "482094541ee3b6379c0bf6e42d96a6e1b2a0024936cebbaf702b9f853cfb124e"

