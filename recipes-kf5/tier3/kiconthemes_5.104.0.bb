# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kiconthemes-5.104.0.tar.xz"
SRC_URI[sha256sum] = "70f4d9f950acdaa28b539838226ed1cff7e70cdcf177272185bac7c75a6cccdf"

