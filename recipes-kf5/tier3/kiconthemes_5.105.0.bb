# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kiconthemes-5.105.0.tar.xz"
SRC_URI[sha256sum] = "15178a35da23f78cbbac1a9d40554c9ed46f4426f7669f463260061f463f23bf"

