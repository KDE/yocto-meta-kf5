# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kiconthemes-5.107.0.tar.xz"
SRC_URI[sha256sum] = "5d17db48bc9d54e0060cc48f77354b2732ec2fc553266a00907c16345426c42f"

