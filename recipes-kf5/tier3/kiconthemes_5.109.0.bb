# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kiconthemes-${PV}.tar.xz"
SRC_URI[sha256sum] = "d319fbb3dbe8e08022690683b7fe27359dd2b036ea52e10f767a63354f68e66c"

