# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kiconthemes-5.110.0.tar.xz"
SRC_URI[sha256sum] = "0d84a2106d68fe040458ea31a8fb63673d0cc48892e606a5875edaa9e4c9662d"

