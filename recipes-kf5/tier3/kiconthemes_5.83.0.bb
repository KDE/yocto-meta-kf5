# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kiconthemes-5.83.0.tar.xz"
SRC_URI[sha256sum] = "9a7f1326a449956db6a0b4826609ca633c0fd92213cba3d634847b999ed1be21"

