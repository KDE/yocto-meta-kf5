# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kiconthemes-5.84.0.tar.xz"
SRC_URI[sha256sum] = "f6dd5e7510217d71df871dc299a6a382e3adbe16f72c6c16b62b75a37b632065"

