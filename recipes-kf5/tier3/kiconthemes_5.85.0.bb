# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kiconthemes-5.85.0.tar.xz"
SRC_URI[sha256sum] = "97b592033ce8f46826824525c7c37915d3fb8b6bed32eb329aa18015ca88d64c"

