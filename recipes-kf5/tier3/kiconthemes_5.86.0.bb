# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kiconthemes-5.86.0.tar.xz"
SRC_URI[sha256sum] = "0613de454b07961d75e5e36a0c799e58b318c13e74e524474fa3b0668ad540e9"

