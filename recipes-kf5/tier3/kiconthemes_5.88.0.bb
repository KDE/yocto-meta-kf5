# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kiconthemes-5.88.0.tar.xz"
SRC_URI[sha256sum] = "f7ab45cb8d7b9a148ec21b64881142b7c04608e6d36f1fa1964e721d8d30e939"

