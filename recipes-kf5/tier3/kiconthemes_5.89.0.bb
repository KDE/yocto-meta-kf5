# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kiconthemes-5.89.0.tar.xz"
SRC_URI[sha256sum] = "4aed2b49a545b31781c195b2a494985ebb86a8dedb036abd7c4a84b7375d68c3"

