# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kiconthemes-5.94.0.tar.xz"
SRC_URI[sha256sum] = "d972d81dcd7ccb74ef4abd4db2a88512a07ea459a301b94e7a98b831ab814993"

