# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kiconthemes-5.96.0.tar.xz"
SRC_URI[sha256sum] = "4f43f28249d4753d07dece4b879fb83f2d0a8217bba861d4b9dd5dd74d493571"

