# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kiconthemes-5.97.0.tar.xz"
SRC_URI[sha256sum] = "94f1c6a8aeabfe5b3f2db4bb308546e4941afbc3ba8743c00ed746b360aa9a11"

