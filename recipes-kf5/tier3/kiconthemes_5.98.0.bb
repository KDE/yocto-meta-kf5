# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kiconthemes-5.98.0.tar.xz"
SRC_URI[sha256sum] = "1d4feb37254f9a03af321b2f0a7b8e4f020528bd258d029be8bc2ef53a6ab4e2"

