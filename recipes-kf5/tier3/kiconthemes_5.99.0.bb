# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kiconthemes-5.99.0.tar.xz"
SRC_URI[sha256sum] = "a426ca5327997c136ca384306a751e6cf25245de237e09ce45cc680032073a05"

