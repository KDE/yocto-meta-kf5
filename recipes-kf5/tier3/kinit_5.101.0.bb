# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kinit-5.101.0.tar.xz"
SRC_URI[sha256sum] = "8e41dba85484db50ea0fbad67316a514a170f94ff78e8879f494c538b97701a4"

