# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kinit-5.103.0.tar.xz"
SRC_URI[sha256sum] = "e558aa014dba92047f166aac24a253c179444de02577d5da43fb8bdfa0565d78"

