# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kinit-5.104.0.tar.xz"
SRC_URI[sha256sum] = "7178689192f75beca0bdde3b265f9c94d5b7a7153206714fecec55ea71bd7234"

