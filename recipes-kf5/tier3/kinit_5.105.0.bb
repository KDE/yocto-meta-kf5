# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kinit-5.105.0.tar.xz"
SRC_URI[sha256sum] = "40dcd052f99cffc3588593495f971a6fb580e82804cbbdf43bf4bd9f2f9ed4ce"

