# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kinit-5.107.0.tar.xz"
SRC_URI[sha256sum] = "cefe344456222c63bbc1738192a11f68e0eff7eac5e32f73e0edb9b8d9a848dc"

