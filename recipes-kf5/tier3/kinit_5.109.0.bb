# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kinit-${PV}.tar.xz"
SRC_URI[sha256sum] = "5d912d4f9802ca99e0628f4bbc2f8dfae8962ee5c83dadd3d96810db9741e1a2"

