# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kinit-5.110.0.tar.xz"
SRC_URI[sha256sum] = "65d338ef945a2108b0f9b88b5ad966abd525e9228b8593f4db5e00075312425f"

