# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kinit-5.83.0.tar.xz"
SRC_URI[sha256sum] = "c164e8df6350b069f634f5e7c42625026088c10886c1b934ab9e5243cc988c8a"

