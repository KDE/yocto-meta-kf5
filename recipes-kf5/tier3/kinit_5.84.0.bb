# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kinit-5.84.0.tar.xz"
SRC_URI[sha256sum] = "fca5dbe4b1646202ca5c2ee9c8f259514b17a633af318d57f225f1aa7616b128"

