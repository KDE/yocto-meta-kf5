# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kinit-5.85.0.tar.xz"
SRC_URI[sha256sum] = "92dfdfc00ba87edb41d228906ea0d5e7ab5381c639845082e1019342cf8ca60e"

