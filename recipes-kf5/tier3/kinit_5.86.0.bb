# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kinit-5.86.0.tar.xz"
SRC_URI[sha256sum] = "270a391b20b7ca4b747115ee99f1a5508ecd02dfbc1efefe81e79cd03be2d568"

