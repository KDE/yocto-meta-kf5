# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kinit-5.88.0.tar.xz"
SRC_URI[sha256sum] = "106448c5b7f2859243cd22c2f04790de78707f6d2926682f3ea39ec4c0b650c2"

