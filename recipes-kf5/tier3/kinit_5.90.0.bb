# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kinit-5.90.0.tar.xz"
SRC_URI[sha256sum] = "2a3858eeb80b044e884bdc77e110e7ecb34cdb91575c544a95502123a183c57c"

