# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kinit-5.93.0.tar.xz"
SRC_URI[sha256sum] = "db36a3bd5b30163b7a4ed8c7a907bec585acab841306755b0d8d32ef3d1ce498"

