# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kinit-5.96.0.tar.xz"
SRC_URI[sha256sum] = "b88dd3dd97791f4c786e89d9bd771675070d030f889c90104b5b8aca2240fdf8"

