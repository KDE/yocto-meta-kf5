# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kinit-5.97.0.tar.xz"
SRC_URI[sha256sum] = "5856ac46acb27be6e5dba041d2cc24b6f430c49379cc97b116d8c0dd40444ca5"

