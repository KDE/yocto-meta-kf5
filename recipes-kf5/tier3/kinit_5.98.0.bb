# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kinit-5.98.0.tar.xz"
SRC_URI[sha256sum] = "81048855d7cbe2a23a990898b369a08e3984129c6bfc573ca4f6463f3e24c510"

