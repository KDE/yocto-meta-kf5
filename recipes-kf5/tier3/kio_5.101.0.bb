# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kio-5.101.0.tar.xz"
SRC_URI[sha256sum] = "25e4d66215b162480ca58728c58a72f49b2a48bd2cc58e8719fbd7dacb79cc63"

