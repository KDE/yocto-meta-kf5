# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kio-5.103.0.tar.xz"
SRC_URI[sha256sum] = "0b4837365aa489cc4007badb21f49e7d7729b758020cf2a0717ab12fbf97f447"

