# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kio-5.104.0.tar.xz"
SRC_URI[sha256sum] = "5a8b93a5de72406fc4cc7b9aa4715be6d1d5264e617b26be257f5d0e26dde310"

