# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kio-5.105.0.tar.xz"
SRC_URI[sha256sum] = "1f971115d3cc488973f74222c9ae3722ac630fa8c02c00d4ba22eb03ceb8677d"

