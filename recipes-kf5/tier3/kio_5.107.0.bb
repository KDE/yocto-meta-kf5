# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kio-5.107.0.tar.xz"
SRC_URI[sha256sum] = "456a1856830c21e9a61181c22c0e14510ad6a4498da0684afc05761142ac48ae"

