# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kio-${PV}.tar.xz"
SRC_URI[sha256sum] = "f65a69ef167f5932c4f0f662ff8eb150aba36476fbcbd806744320a1049c0c62"

