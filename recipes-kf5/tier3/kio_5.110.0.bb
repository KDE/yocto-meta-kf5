# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kio-5.110.0.tar.xz"
SRC_URI[sha256sum] = "228f9abcdfce1b23deacca97e9dd68d019e6b20607ddfe2295050333e90fc96b"

