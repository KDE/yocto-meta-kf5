# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kio-5.83.0.tar.xz"
SRC_URI[sha256sum] = "faa5a519e0cccb7197a4025f4b267a7683b49ad9d03e730a57969f33072f51c1"

