# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kio-5.84.0.tar.xz"
SRC_URI[sha256sum] = "96be2b732faf97a484edc5238049ad22f0f233b9e404468f4da40c5ec839e0d3"

