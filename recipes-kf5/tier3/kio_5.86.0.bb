# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kio-5.86.0.tar.xz"
SRC_URI[sha256sum] = "d699faf3561c08c0cfee507c9a009b8be1ceacadce67c22151c4879d33cf7e06"

