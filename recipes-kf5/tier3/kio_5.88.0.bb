# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kio-5.88.0.tar.xz"
SRC_URI[sha256sum] = "ffd4aa4277ce545a50ee01783eeb92ca060094fc582c1affd8186c9df0d4a66c"

