# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kio-5.89.0.tar.xz"
SRC_URI[sha256sum] = "dd821fe65fd5a80d57e572c5d1074290ca183a0ca91bd9092747d72399d148cd"

