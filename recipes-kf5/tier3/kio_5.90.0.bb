# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kio-5.90.0.tar.xz"
SRC_URI[sha256sum] = "3a1f2eb6453172ecb5b9936c6a5205306e9e729f19bec6bf12527eef8a214637"

