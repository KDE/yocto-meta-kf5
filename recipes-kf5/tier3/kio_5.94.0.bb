# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kio-5.94.0.tar.xz"
SRC_URI[sha256sum] = "85c0bf8e49d845730d95c85c0292330a5bf03ed63a008cbf02ec9d02f990d09b"

