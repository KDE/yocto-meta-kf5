# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kio-5.96.0.tar.xz"
SRC_URI[sha256sum] = "95983904cd01c31b7fffbf615765485029192b2352f6672b8b7386cb0e7ebb76"

