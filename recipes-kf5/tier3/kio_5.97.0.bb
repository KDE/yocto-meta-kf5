# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kio-5.97.0.tar.xz"
SRC_URI[sha256sum] = "cc9b80507a8eb49470b9352c4171ab194cc6ab3cb6e80793d6c7a05181675887"

