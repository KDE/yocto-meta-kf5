# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kio-5.98.0.tar.xz"
SRC_URI[sha256sum] = "2dd4b9c96da113b6b9b2a48b1083805706defb44640b6844ab785835d49d317c"

