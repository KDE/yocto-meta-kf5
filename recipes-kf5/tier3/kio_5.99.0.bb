# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kio-5.99.0.tar.xz"
SRC_URI[sha256sum] = "efd2bf49ba5233c82983309af3b93e59b185ed9d1f9b6e1a6de2f556f33fa87c"

