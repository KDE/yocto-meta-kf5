# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/knewstuff-5.101.0.tar.xz"
SRC_URI[sha256sum] = "e7112b0b8b766f3300e93fb35bad830510fd16fc86770c3a4833f509ceffcff5"

