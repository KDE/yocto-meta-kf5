# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/knewstuff-5.103.0.tar.xz"
SRC_URI[sha256sum] = "46ba797c01fa258585968c5cad0051323cc24b7cc794714fefd7a79c1deab78e"

