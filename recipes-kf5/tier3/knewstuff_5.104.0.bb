# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/knewstuff-5.104.0.tar.xz"
SRC_URI[sha256sum] = "f89bcf39756f87a6dc16a0d2adf7dd78d5712aef4c9b6d7082b588f8f0354a5c"

