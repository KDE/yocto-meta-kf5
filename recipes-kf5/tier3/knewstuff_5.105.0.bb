# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/knewstuff-5.105.0.tar.xz"
SRC_URI[sha256sum] = "8758cbbae12cd0405614cb9a0ff57fa66899e31187fb7a027cfca91b48f5fc7e"

