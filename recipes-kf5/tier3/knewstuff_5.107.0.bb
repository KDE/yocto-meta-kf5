# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/knewstuff-5.107.0.tar.xz"
SRC_URI[sha256sum] = "78d935ba41d525a803bc6335f9f5cbe7c2972000d3544e7621cb5771ab92f29b"

