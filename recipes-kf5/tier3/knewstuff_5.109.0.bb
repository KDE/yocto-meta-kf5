# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/knewstuff-${PV}.tar.xz"
SRC_URI[sha256sum] = "3fc8e70c1f8a14e02c4f0b95ec564cac44e2f2cb0669764bb5616988efa1076e"

