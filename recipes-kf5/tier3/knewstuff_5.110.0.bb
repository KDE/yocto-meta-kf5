# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/knewstuff-5.110.0.tar.xz"
SRC_URI[sha256sum] = "74ad95ea18b42b00f4b3d51bfe0bdcfebf5e40c26a27c569c3c0fce365448d62"

