# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/knewstuff-5.83.0.tar.xz"
SRC_URI[sha256sum] = "0c3b5cb45eecadcebaa524ae26f0a2e8b8cb456f6e2831bf1065e4c2362ce687"

