# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/knewstuff-5.84.0.tar.xz"
SRC_URI[sha256sum] = "aea889085e662b1b3566f0beb62b01a3c4aa9f1d2b1076789dc7d14ec0392bf8"

