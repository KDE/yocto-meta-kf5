# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/knewstuff-5.85.0.tar.xz"
SRC_URI[sha256sum] = "f0c68fd75eb18d8c70ca27031b273774fe33c38c72fdf86254cfe3c09df620c9"

