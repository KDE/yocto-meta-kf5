# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/knewstuff-5.86.0.tar.xz"
SRC_URI[sha256sum] = "26f8b88add9050201e7871349adb3996d75d1ab047aa1a24279743e1425b75b0"

