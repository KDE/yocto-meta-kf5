# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/knewstuff-5.88.0.tar.xz"
SRC_URI[sha256sum] = "f73689a88bf5042075baefd1b5bbfa10e58997c98aeccd36cb9292e6efc076f9"

