# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/knewstuff-5.89.0.tar.xz"
SRC_URI[sha256sum] = "8568a0b2e4f1f63a32084d37f1d322f257978ac41f7812463e5475b949a583e3"

