# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/knewstuff-5.90.0.tar.xz"
SRC_URI[sha256sum] = "8f89ab148271822128ac7469de98f3e4ade2eb890361741f1177bc5ffeb96060"

