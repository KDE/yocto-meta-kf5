# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/knewstuff-5.93.0.tar.xz"
SRC_URI[sha256sum] = "2adc48e26c04c05f61f6ff1007f77ea43036b76d769535617e88d3f35ebb5759"

