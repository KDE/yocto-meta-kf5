# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/knewstuff-5.94.0.tar.xz"
SRC_URI[sha256sum] = "aacd014f99ab66d40ae98333cb56257244ca552bc4df0ce04de4e29bae90336f"

