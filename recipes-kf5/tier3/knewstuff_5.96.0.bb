# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/knewstuff-5.96.0.tar.xz"
SRC_URI[sha256sum] = "ecb980e21b0906d4f0f5f1d49909a450f1aef440762207a5cb114f4c39209a4e"

