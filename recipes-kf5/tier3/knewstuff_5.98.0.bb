# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/knewstuff-5.98.0.tar.xz"
SRC_URI[sha256sum] = "fe39443e0092cd158dcde442e0c442b14e9d5194b6bd6112ad25060af6fdbd26"

