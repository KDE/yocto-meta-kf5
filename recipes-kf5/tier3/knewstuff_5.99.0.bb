# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/knewstuff-5.99.0.tar.xz"
SRC_URI[sha256sum] = "4824b6aa08c58671b182ba489d45a83122b522315750cc90cf8f544337d4a72d"

