# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/knotifyconfig-5.101.0.tar.xz"
SRC_URI[sha256sum] = "5c257ad4ee8ab9b2717461181e6f44f6cd1fe85b901b6e79b8133ef42583f601"

