# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/knotifyconfig-5.102.0.tar.xz"
SRC_URI[sha256sum] = "08e20422083f0171d5d9b55e666d132d938d523b4fa6257b1e3c0075d8b74817"

