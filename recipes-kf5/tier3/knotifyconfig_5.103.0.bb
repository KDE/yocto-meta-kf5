# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/knotifyconfig-5.103.0.tar.xz"
SRC_URI[sha256sum] = "5aba75b515b8a95b54edf3245ecdb3338bad37f296f0e95b012905a35bd1297d"

