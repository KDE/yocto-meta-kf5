# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/knotifyconfig-5.104.0.tar.xz"
SRC_URI[sha256sum] = "4da2f2c76378b7aaa2de5cc6d45a068567f4fdc2a66897c6b1ef3002922dae28"

