# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/knotifyconfig-5.105.0.tar.xz"
SRC_URI[sha256sum] = "e2ba0087bf8bb80c4d5d15da4b6f0519d643da5ac990e7bd757214118b9477c3"

