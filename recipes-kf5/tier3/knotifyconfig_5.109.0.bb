# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/knotifyconfig-${PV}.tar.xz"
SRC_URI[sha256sum] = "9a9e9efd6248f1990b6327ce7c6fe1a689424aae114467af996b3e5b1def48d1"

