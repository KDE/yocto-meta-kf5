# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/knotifyconfig-5.110.0.tar.xz"
SRC_URI[sha256sum] = "971f6b08715d383514bdf7e5bbd484f17ab4f48fb28d5533ba98a2ad00cca198"

