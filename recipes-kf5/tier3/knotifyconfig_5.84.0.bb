# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/knotifyconfig-5.84.0.tar.xz"
SRC_URI[sha256sum] = "c25fab67f21210cbcd79a8a89fc20f549586ae75df106a07e56a052598b8f2f4"

