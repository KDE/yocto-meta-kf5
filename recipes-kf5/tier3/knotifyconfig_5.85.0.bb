# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/knotifyconfig-5.85.0.tar.xz"
SRC_URI[sha256sum] = "dbd51384750c62881d0435db13a278dfb4699b31aa0c83a6cbbf7e924facf0aa"

