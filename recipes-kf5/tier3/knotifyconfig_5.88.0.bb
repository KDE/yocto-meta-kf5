# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/knotifyconfig-5.88.0.tar.xz"
SRC_URI[sha256sum] = "0033f594d93c7a23a4203dedaf3ab0b07e840862f85fe240b0b5171f4f39706c"

