# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/knotifyconfig-5.89.0.tar.xz"
SRC_URI[sha256sum] = "509e16bfa83e4a97cf6f4420ad54ee0e3507dfddf7d2ef9fef65440dbbb53810"

