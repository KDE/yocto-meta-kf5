# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/knotifyconfig-5.90.0.tar.xz"
SRC_URI[sha256sum] = "cc24c2dfdb2f2bea29aef8f56d5183a3caf73f5d3515ba3de9e9ab9335205ae3"

