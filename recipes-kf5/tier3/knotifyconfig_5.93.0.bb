# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/knotifyconfig-5.93.0.tar.xz"
SRC_URI[sha256sum] = "cc9de166631555451965cd007b82f0ab529d6b909bc259e26e59feee586619cd"

