# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/knotifyconfig-5.96.0.tar.xz"
SRC_URI[sha256sum] = "a2b9fd0dfbb7cd5b535ceb58788f42823cea2fadf30de4ceb43a9bfb0fe16c25"

