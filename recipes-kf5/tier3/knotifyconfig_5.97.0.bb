# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/knotifyconfig-5.97.0.tar.xz"
SRC_URI[sha256sum] = "1bda7bb052c6316058cf93d2d6f0a79da0f71aa8ed633f5cd0e7874908738dfa"

