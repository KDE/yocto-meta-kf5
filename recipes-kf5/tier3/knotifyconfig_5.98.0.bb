# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/knotifyconfig-5.98.0.tar.xz"
SRC_URI[sha256sum] = "07d4f5f8888ea6a284e77843d391f46e8a334de5d261343fbacfbb984b7e95e2"

