# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kparts-5.101.0.tar.xz"
SRC_URI[sha256sum] = "daae37f79c13276376f269f341121414779cbbec214956997c393b4c32435697"

