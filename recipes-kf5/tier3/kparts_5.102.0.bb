# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kparts-5.102.0.tar.xz"
SRC_URI[sha256sum] = "37caeeb5e66bbec0d38b76c1a0ea3085be77d581375a4837f5717e7e1d616f1f"

