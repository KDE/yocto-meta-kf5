# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kparts-5.103.0.tar.xz"
SRC_URI[sha256sum] = "5f0d2fc481cb227675b9d9d1a9dc0c97cfc286cbf33c8035fa63e1bacf93b571"

