# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kparts-5.104.0.tar.xz"
SRC_URI[sha256sum] = "66a40646cc4890669991cc63d33803ec335b0c08b7aeb0476b2a852951e700cd"

