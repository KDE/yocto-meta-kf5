# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kparts-5.105.0.tar.xz"
SRC_URI[sha256sum] = "ab0033760fcd76d0d156481e026de3b545191b9a3c6cc7e2316fa8c50d95b79c"

