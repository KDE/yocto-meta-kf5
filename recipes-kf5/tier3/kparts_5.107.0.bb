# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kparts-5.107.0.tar.xz"
SRC_URI[sha256sum] = "00b8558644928e4cc1f43de64a74696d038add33895522e085809c9c9a8fa9fb"

