# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kparts-${PV}.tar.xz"
SRC_URI[sha256sum] = "6b1da5f8c00c2204e9da1eb6767e00f72a966d1152073515bb677f0e7734f79e"

