# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kparts-5.110.0.tar.xz"
SRC_URI[sha256sum] = "23a381ee316730ee5fcc7caee9d71b0f0d8cd09256bd6ed1f67bbd37c5465b8d"

