# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kparts-5.83.0.tar.xz"
SRC_URI[sha256sum] = "be087bbfba0735dacf3140f3a23bb08bc1c06d4665c1ed36175a734f5e321aae"

