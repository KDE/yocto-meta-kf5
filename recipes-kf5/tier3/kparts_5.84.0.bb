# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kparts-5.84.0.tar.xz"
SRC_URI[sha256sum] = "deeda3f10b806b1822bed7573fb5f6c2ba76c465c8c76bbf85696f173af775b9"

