# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kparts-5.86.0.tar.xz"
SRC_URI[sha256sum] = "40bd41a970c9a85d38a31e243f4db49b867e75b509d2c6591a4c7d1eb2720120"

