# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kparts-5.88.0.tar.xz"
SRC_URI[sha256sum] = "74ef0eff2b87ec65256691f9124a89b4010a83541b93b6325020541ecabcfbbd"

