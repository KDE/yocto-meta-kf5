# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kparts-5.89.0.tar.xz"
SRC_URI[sha256sum] = "2a973890e045028d2938753040343342e0c88444d773afa9f556f489bb0ebf6d"

