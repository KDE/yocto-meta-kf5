# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kparts-5.94.0.tar.xz"
SRC_URI[sha256sum] = "05a5120f1a97dce84f5ea85d80eb4eb50793f800ce2af055d1d73ce61ed06bba"

