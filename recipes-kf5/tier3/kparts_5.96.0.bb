# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kparts-5.96.0.tar.xz"
SRC_URI[sha256sum] = "02daf869ec02218343601a115b0ee20663e37e8682528dd2e1cd0e7aa29fc82c"

