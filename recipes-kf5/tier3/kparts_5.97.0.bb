# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kparts-5.97.0.tar.xz"
SRC_URI[sha256sum] = "ef833d4a5165445c148186da0d7c977a72d1606cf07fcf6ff8e9d4c48e532551"

