# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kparts-5.98.0.tar.xz"
SRC_URI[sha256sum] = "f9ed944817efb4298753812ae70310b9a49c46c85968cec8a4fce5bfb8b7ec05"

