# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kparts-5.99.0.tar.xz"
SRC_URI[sha256sum] = "003220ff87733be6da6076207ab66a67a8745fd395d1250ebd978c0c430e7c5e"

