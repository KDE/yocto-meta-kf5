# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kpeople-5.101.0.tar.xz"
SRC_URI[sha256sum] = "ca8d436310fe20a6b01463f0cf0ae7f33cb23efb1a5f5395f20bdfe92c9c5a72"

