# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kpeople-5.102.0.tar.xz"
SRC_URI[sha256sum] = "623743a8521a8eace1d0006f6e5f8300cdd1fdb40b22e7cd5f61cbf1154720f2"

