# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kpeople-5.103.0.tar.xz"
SRC_URI[sha256sum] = "15d5dedaf8d78c6ac776895e4dcaee7bd83a74a4556d42d5a3aa713a1978382c"

