# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kpeople-5.104.0.tar.xz"
SRC_URI[sha256sum] = "820be511c7eaf0a64ec1505fc59f7502ecdcfa4e2593c4fce501e0470a2e6c96"

