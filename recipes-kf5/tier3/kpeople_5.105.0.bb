# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kpeople-5.105.0.tar.xz"
SRC_URI[sha256sum] = "ac098e548cdb9be91e035e15ad9b923bb7d0fe490562bbed16245a6cf40d4706"

