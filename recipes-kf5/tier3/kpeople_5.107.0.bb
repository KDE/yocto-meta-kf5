# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kpeople-5.107.0.tar.xz"
SRC_URI[sha256sum] = "925e6eb326846b01c31eb013be0858e1c48e590fdb4e4274e3f92d9c224b19a2"

