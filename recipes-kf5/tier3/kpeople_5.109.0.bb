# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kpeople-${PV}.tar.xz"
SRC_URI[sha256sum] = "3d5e711132ae3f7ce5b8413ad2ee0350be9f50c21119e9609e86a997d0f4b9be"

