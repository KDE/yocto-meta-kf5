# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kpeople-5.110.0.tar.xz"
SRC_URI[sha256sum] = "f700e48269fc5dfb5f56e84556f5484d5b0b0f589d45a769831800cea463b981"

