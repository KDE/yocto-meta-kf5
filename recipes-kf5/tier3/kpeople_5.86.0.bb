# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kpeople-5.86.0.tar.xz"
SRC_URI[sha256sum] = "d0e11c56966c34a55c86de5e90d738c28c23a133844dca6dc2624d5a63d079f9"

