# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kpeople-5.90.0.tar.xz"
SRC_URI[sha256sum] = "fc3938d53fe2badb91e8f93a34afaa50f40b3610062fb5901d36d955cc986298"

