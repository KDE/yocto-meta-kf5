# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kpeople-5.93.0.tar.xz"
SRC_URI[sha256sum] = "d3e1266982fa2abdd7b216d018569ea83c71312e2cfa35a0bee845e8bb49f371"

