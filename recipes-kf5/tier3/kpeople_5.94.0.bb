# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kpeople-5.94.0.tar.xz"
SRC_URI[sha256sum] = "217eba378c223e3518914512fc303a106101d26fa1a8fc57495abbd0d36a5274"

