# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kpeople-5.96.0.tar.xz"
SRC_URI[sha256sum] = "ab84002eb7033f4cbc53eeca900844a139ae8fe20c4083592f7526d5e1036c60"

