# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kpeople-5.98.0.tar.xz"
SRC_URI[sha256sum] = "0ee89b53c502a9cd215d43e56ee63265b20fb508098f9d22590bbb35fb45be73"

