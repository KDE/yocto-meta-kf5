# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kpeople-5.99.0.tar.xz"
SRC_URI[sha256sum] = "7f05f4059d85371fafb9bbd1023b5995b6f8986c3fc4745a65f60513f71b663d"

