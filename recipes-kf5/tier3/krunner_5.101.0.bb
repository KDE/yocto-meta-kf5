# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/krunner-5.101.0.tar.xz"
SRC_URI[sha256sum] = "d25fcc168234777352dd4d11ac0f46a916d6b17d4cd9078e3a615a7804865fa6"

