# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/krunner-5.102.0.tar.xz"
SRC_URI[sha256sum] = "ce7d2c0ea598362b15e867196697871f6100a2c9d333b969800adf23d1aa6b3f"

