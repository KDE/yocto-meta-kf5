# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/krunner-5.103.0.tar.xz"
SRC_URI[sha256sum] = "05e89ea5f996caf8bc7df13f340eb33066edb98b29c8e367ede261eacc15ca72"

