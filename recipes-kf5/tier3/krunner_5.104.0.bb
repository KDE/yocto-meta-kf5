# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/krunner-5.104.0.tar.xz"
SRC_URI[sha256sum] = "5a7269e9e5b6ea805b8ddfe1c714360512d6ebcc0e1ba06b4ab03bc7322c78a4"

