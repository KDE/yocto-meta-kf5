# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/krunner-5.105.0.tar.xz"
SRC_URI[sha256sum] = "785b8ad02cb61452c6f82a1ff632539b492399c1832c153fa6eb1fd35b6daf08"

