# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/krunner-5.107.0.tar.xz"
SRC_URI[sha256sum] = "75c8e8022c131b339426c38a5fdfc7c33ddf30b211fae9cebe2e4a0cab3c221b"

