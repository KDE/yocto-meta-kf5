# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/krunner-${PV}.tar.xz"
SRC_URI[sha256sum] = "5c0ca1c745644a16590f3299384f40b04bd73f4842a63f228e166afab246f35f"

