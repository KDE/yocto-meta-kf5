# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/krunner-5.110.0.tar.xz"
SRC_URI[sha256sum] = "a18c18e252f8a36bb866b0df8846d55d670336fd11f6d97291d872cd04867260"

