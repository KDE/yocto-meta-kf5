# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/krunner-5.83.0.tar.xz"
SRC_URI[sha256sum] = "a2c44640acdda78a76581d4b62e389439c8270d838ef64774b1fa8daa9b4db0a"

