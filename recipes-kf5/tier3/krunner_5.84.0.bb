# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/krunner-5.84.0.tar.xz"
SRC_URI[sha256sum] = "37a8049e2161cfaa2659160fef0734c5a918a522ec40888fdca5c2b2530f5195"

