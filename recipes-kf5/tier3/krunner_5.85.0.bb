# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/krunner-5.85.0.tar.xz"
SRC_URI[sha256sum] = "8dc01236134640daab49dcee77227a11d4582feb58e3c6856ca3e12caf31e4df"

