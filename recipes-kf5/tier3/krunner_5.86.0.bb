# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/krunner-5.86.0.tar.xz"
SRC_URI[sha256sum] = "5161b7d62ded9299c9e08c994a1e74880445e6a84c46709961d55e51bf0ea39d"

