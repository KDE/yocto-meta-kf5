# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/krunner-5.94.0.tar.xz"
SRC_URI[sha256sum] = "32b0bcda190884f9de2f8a598c854ed2d29cab199dda5d341364913321b7cbd1"

