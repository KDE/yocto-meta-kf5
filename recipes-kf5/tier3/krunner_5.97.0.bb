# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/krunner-5.97.0.tar.xz"
SRC_URI[sha256sum] = "295fb5f03c7c806bed68b358f4de517ad8a8758c9abd10f5761f3f0b39d8ad29"

