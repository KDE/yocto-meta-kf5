# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kservice-5.101.0.tar.xz"
SRC_URI[sha256sum] = "fc398700243962691119f4653b2c6f4ab379cdcb2728fd309b55fc1d8047c6b2"

