# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kservice-5.102.0.tar.xz"
SRC_URI[sha256sum] = "7063862f169095a2a3d5a4594e7724b74b5e50dd1f5b16fcc0fde0ba16d99ade"

