# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kservice-5.103.0.tar.xz"
SRC_URI[sha256sum] = "d8a03b319d3b386594098e9ffe95bfcd32a7d34172cb5a0e35dd4c7c48ed0a39"

