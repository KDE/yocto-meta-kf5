# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kservice-5.104.0.tar.xz"
SRC_URI[sha256sum] = "215b109738ea5a10f97c4abbd3c9b9da58c826127708eddd34af345b4e8ad8a3"

