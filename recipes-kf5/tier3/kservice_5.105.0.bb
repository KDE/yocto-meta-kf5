# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kservice-5.105.0.tar.xz"
SRC_URI[sha256sum] = "b1010940954040f4a0ed096901e7393f26f262d79b5e904da2247b2602e3c70c"

