# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kservice-5.107.0.tar.xz"
SRC_URI[sha256sum] = "063f6d41921d797553204fe625c1c4720e1b7b1a71163c5d594eb210b614f92d"

