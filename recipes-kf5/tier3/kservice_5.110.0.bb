# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kservice-5.110.0.tar.xz"
SRC_URI[sha256sum] = "efc1d6e3338812b2170a7a9319da1006a1709e295c23fedb28bcb26ad2363666"

