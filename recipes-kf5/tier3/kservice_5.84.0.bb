# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kservice-5.84.0.tar.xz"
SRC_URI[sha256sum] = "c2e9c7a87aa7835d7bbfb0f45838a76151733547807a80c86df8307d79287dd1"

