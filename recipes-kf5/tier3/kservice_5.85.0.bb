# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kservice-5.85.0.tar.xz"
SRC_URI[sha256sum] = "e2d1b7436a2bc8a73b4eec486bb8308a7997c65b981f88b17977bf15a5290b01"

