# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kservice-5.86.0.tar.xz"
SRC_URI[sha256sum] = "46e1a212d8e0be9f046543b4284ea5e6ed7ba4aabff564b3992bdff6affbd93a"

