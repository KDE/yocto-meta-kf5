# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kservice-5.88.0.tar.xz"
SRC_URI[sha256sum] = "841e572bd74f267375dca5dc5c7561162a12bca2c76b11a6860ea14fe2416aa9"

