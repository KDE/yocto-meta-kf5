# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kservice-5.89.0.tar.xz"
SRC_URI[sha256sum] = "05670a04fae5753fddcda1d1fe13680afd077fc1ec17d8f53f5c80f1bf922b6b"

