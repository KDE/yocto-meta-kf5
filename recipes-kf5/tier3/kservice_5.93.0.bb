# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kservice-5.93.0.tar.xz"
SRC_URI[sha256sum] = "46cf92f837fb890e311c5affaaa8b01d1d66b47dd272a30ae148472ef3e67431"

