# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kservice-5.94.0.tar.xz"
SRC_URI[sha256sum] = "1aad105fc0a4060b1cbe6e29f96f93a01af254159c9263c080d94e4eeae43b32"

