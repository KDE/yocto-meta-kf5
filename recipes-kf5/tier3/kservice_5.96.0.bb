# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kservice-5.96.0.tar.xz"
SRC_URI[sha256sum] = "ed99b8ad1ed141fbd38ef1bd0cba5045839c181f3a3d5a672c6a215fcb50e3fd"

