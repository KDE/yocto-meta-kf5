# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kservice-5.97.0.tar.xz"
SRC_URI[sha256sum] = "6d0016a801edbd2989a13a3cf460b1164663c9b205ced8f9242f256a1b3e202e"

