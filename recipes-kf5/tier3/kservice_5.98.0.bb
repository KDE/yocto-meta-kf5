# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kservice-5.98.0.tar.xz"
SRC_URI[sha256sum] = "6150e8995aa0b2ea6f426cb2f23b662a02cf5bae5e95fb09c2bcaf391bbbfc51"

