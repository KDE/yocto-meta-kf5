# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kservice-5.99.0.tar.xz"
SRC_URI[sha256sum] = "1a50ab72e833375bbad75f41d53f2d1059c8ac11d014b4481eef0825b1fd4665"

