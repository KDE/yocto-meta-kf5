# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/ktexteditor-5.101.0.tar.xz"
SRC_URI[sha256sum] = "107cd3035f41538eb1d5add58ee1a27cc9fa9c7b69f9db18232419498ac55dc4"

