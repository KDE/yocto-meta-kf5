# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/ktexteditor-5.102.0.tar.xz"
SRC_URI[sha256sum] = "5cc8b93caa2afa2a0b2432f147961dc8668a645ef2b8f996cc4b4d9b0d8a73cf"

