# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/ktexteditor-5.103.0.tar.xz"
SRC_URI[sha256sum] = "622c651dabde55956c14d5a0be50cadd0da109e128327352851c9199bbeee50f"

