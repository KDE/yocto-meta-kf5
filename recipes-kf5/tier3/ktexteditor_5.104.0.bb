# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/ktexteditor-5.104.0.tar.xz"
SRC_URI[sha256sum] = "2ce11d77fbf0939db3e7f833c4cc454b97315819f9a72c8bc6828d86c2fb51e6"

