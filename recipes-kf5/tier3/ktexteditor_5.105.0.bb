# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/ktexteditor-5.105.0.tar.xz"
SRC_URI[sha256sum] = "96e9dec29a59a6f0fc939b4496dc36138b9d5221e8d1b6c3645ca3d93fd85106"

