# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/ktexteditor-5.107.0.tar.xz"
SRC_URI[sha256sum] = "8f91c74da11b856b0a228d080c592e360ce80c9020cbe0d8673dd6b6cacebc98"

