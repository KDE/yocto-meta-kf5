# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/ktexteditor-${PV}.tar.xz"
SRC_URI[sha256sum] = "dca1bc529e7156ebb1c4ce2361adbced3f8e2619fd720fda9f0421b57992f2ad"

