# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/ktexteditor-5.110.0.tar.xz"
SRC_URI[sha256sum] = "8abee8fb575dc9d99580eac5b21370ccb1bdd2ef9504b5db44b98e3a43e19f47"

