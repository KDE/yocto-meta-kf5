# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/ktexteditor-5.83.0.tar.xz"
SRC_URI[sha256sum] = "6232995e71b7b64abd3d3268e07a05923363dafc7229b7487e118d0aa432039e"

