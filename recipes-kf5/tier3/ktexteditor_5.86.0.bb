# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/ktexteditor-5.86.0.tar.xz"
SRC_URI[sha256sum] = "6283fee0dbf2e342b227026a98acfb5eecfe54dc26791e22a77271b07542eeb8"

