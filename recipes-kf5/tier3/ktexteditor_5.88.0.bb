# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/ktexteditor-5.88.0.tar.xz"
SRC_URI[sha256sum] = "25bf3c6e50ccb744d29cf4cf704ef499143a00f66ce9f98464b68ae68f9af3c5"

