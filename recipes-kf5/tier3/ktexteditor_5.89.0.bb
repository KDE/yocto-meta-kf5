# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/ktexteditor-5.89.0.tar.xz"
SRC_URI[sha256sum] = "67ad913c86a0845d097e3145e15d7218480e1af87133561da7b2295c1b416f09"

