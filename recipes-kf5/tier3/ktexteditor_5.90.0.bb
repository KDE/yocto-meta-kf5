# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/ktexteditor-5.90.0.tar.xz"
SRC_URI[sha256sum] = "56088115827ae406dcd383e3c3fdf408950f351887259e41965fe4b7929f2dbc"

