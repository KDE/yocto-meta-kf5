# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/ktexteditor-5.94.0.tar.xz"
SRC_URI[sha256sum] = "d82d9997167d718ab821dce40e8752205a5ab60f2e69a1bffaf2265455e1b3b6"

