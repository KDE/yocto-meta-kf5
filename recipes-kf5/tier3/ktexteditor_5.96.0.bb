# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/ktexteditor-5.96.0.tar.xz"
SRC_URI[sha256sum] = "03857b651e8a1fd89285f4a3271b257976d4b92b981d13e00a637ae68de8321c"

