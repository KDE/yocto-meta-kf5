# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/ktexteditor-5.97.0.tar.xz"
SRC_URI[sha256sum] = "8b728bf715ce19725e63fa8a19171f9b61ee85425f0fd4e64669d16fc6811c0a"

