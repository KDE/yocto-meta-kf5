# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/ktexteditor-5.98.0.tar.xz"
SRC_URI[sha256sum] = "7c1f6b11eb4a73af156b955604da6360b18c14f546b4a3c378256df2738a5fdd"

