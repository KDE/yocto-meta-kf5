# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/ktexteditor-5.99.0.tar.xz"
SRC_URI[sha256sum] = "123d5cd554c6c90be65735f63b05a075205edf0701580f0d0fa7d9c23417868c"

