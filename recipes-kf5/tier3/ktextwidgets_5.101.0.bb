# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/ktextwidgets-5.101.0.tar.xz"
SRC_URI[sha256sum] = "e9871644bd2ad593fee0e031066388d1ef3184d2403b56b1f3dbf9cecc39c43c"

