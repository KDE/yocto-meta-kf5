# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/ktextwidgets-5.102.0.tar.xz"
SRC_URI[sha256sum] = "4c82dcdc3d650f37530e171de03e612b41d235b35deffd449f173ba881a237b2"

