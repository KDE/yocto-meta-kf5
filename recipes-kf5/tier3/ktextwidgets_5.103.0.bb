# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/ktextwidgets-5.103.0.tar.xz"
SRC_URI[sha256sum] = "95e029aaae1b80669c9e1b241797645dabf562c5a1ceb68e398d0a06d969b5e7"

