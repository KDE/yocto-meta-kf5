# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/ktextwidgets-5.104.0.tar.xz"
SRC_URI[sha256sum] = "48fe28cbe8a54b1227a0ce502c3f4534e46789a4988db44b2e5f362ee2e17dea"

