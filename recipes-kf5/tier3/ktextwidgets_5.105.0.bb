# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/ktextwidgets-5.105.0.tar.xz"
SRC_URI[sha256sum] = "0e5fb51544ef0ec3435a855e870143359a57b6a7a9a1ee51c36a56dd576e68fd"

