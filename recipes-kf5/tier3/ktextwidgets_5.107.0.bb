# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/ktextwidgets-5.107.0.tar.xz"
SRC_URI[sha256sum] = "5e66b07f271a9aae03795ed1baef542460d77ede06987e312f56ebf2376da0fb"

