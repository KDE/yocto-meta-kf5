# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/ktextwidgets-${PV}.tar.xz"
SRC_URI[sha256sum] = "380d02e7deefe33cb0ca8c5125dd1e1636510a0843b455a999be2c45571e1da0"

