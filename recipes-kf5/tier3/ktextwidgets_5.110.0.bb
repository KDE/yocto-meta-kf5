# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/ktextwidgets-5.110.0.tar.xz"
SRC_URI[sha256sum] = "f85c994925eb53a21fd94aa63e63552071206fc81a62af7d43224d5551b12733"

