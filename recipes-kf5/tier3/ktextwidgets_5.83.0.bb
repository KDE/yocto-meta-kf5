# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/ktextwidgets-5.83.0.tar.xz"
SRC_URI[sha256sum] = "0a80d78f08452f48240208e6e108b515b1675ef7283bc46c078b9c62afb47399"

