# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/ktextwidgets-5.84.0.tar.xz"
SRC_URI[sha256sum] = "d4e1213e5475ec2f58f51206ef0473e324f834c1735fc81e8e49399d5d983819"

