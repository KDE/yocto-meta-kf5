# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/ktextwidgets-5.85.0.tar.xz"
SRC_URI[sha256sum] = "fe1bac3c4a68bb97e8f0f003a6d59f0477012be5fd8ba13f885868e015931289"

