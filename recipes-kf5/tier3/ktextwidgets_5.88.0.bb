# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/ktextwidgets-5.88.0.tar.xz"
SRC_URI[sha256sum] = "33660e1e3e59f194250873ca59e6c8be375fc114b8c9ba44bd1dd7a97990d719"

