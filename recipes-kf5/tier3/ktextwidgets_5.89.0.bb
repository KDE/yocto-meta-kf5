# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/ktextwidgets-5.89.0.tar.xz"
SRC_URI[sha256sum] = "94b1fa24dba303d94a1cd8654ab606ee3e3286d50721e402fe414b1842f0e27b"

