# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/ktextwidgets-5.90.0.tar.xz"
SRC_URI[sha256sum] = "4ff6a600f5a48086edb4b056ad8482a1913dd1858729e606d70e1a08d52fe809"

