# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/ktextwidgets-5.93.0.tar.xz"
SRC_URI[sha256sum] = "e27f588929db35f485ebbd6ddec45ec0c56f86844935013f8a39df8bdfb7c215"

