# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/ktextwidgets-5.94.0.tar.xz"
SRC_URI[sha256sum] = "44fceedacb526f4c3c66c1d55257bb39881c7dcca55dae0deccefd84399ed866"

