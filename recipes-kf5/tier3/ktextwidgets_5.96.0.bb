# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/ktextwidgets-5.96.0.tar.xz"
SRC_URI[sha256sum] = "f2fe2c61b5574466d19c6bca4779ac2da3cf9650b19bfef94246248c2b264bed"

