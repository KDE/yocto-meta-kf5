# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/ktextwidgets-5.98.0.tar.xz"
SRC_URI[sha256sum] = "93521275dc96294e488d41d5dc987c1dffa5a441cd4fd3c7d439f5f3ecad3b92"

