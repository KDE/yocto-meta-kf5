# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/ktextwidgets-5.99.0.tar.xz"
SRC_URI[sha256sum] = "31e8dff053f866f0972febd7f78b680e8a015d0e17cef4e2dfdc446892b469a8"

