# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kwallet-5.101.0.tar.xz"
SRC_URI[sha256sum] = "ca0197fa350b8336ab8c7f0b142cbaf58f9ed8e8410b22f9bc7ae2e3bd7a5457"

