# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kwallet-5.102.0.tar.xz"
SRC_URI[sha256sum] = "a311f080a5e9a3d0c13ae115935a57c2fcaca0fa0ef8773c09b3f5e5f1640983"

