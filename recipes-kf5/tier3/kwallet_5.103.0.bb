# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kwallet-5.103.0.tar.xz"
SRC_URI[sha256sum] = "2a97e95b725a83e578e679569c40fbab3ef091475a00d4bd1ef3d98b2ffef23f"

