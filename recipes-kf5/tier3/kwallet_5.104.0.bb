# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kwallet-5.104.0.tar.xz"
SRC_URI[sha256sum] = "6058420bf4cae573bda927be5762f76c9bd026872662b52c90491cf30c3a3bb5"

