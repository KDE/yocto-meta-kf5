# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kwallet-5.105.0.tar.xz"
SRC_URI[sha256sum] = "0deb1f27398c41caef6ad56ff151d2c1a59740abc1d6c578b502d31522249ef9"

