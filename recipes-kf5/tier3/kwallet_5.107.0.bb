# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kwallet-5.107.0.tar.xz"
SRC_URI[sha256sum] = "2e796a011f337ea3305a11bfe2c0e49b71720569207361c65d5bbe85f71b1d77"

