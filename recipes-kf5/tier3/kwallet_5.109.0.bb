# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kwallet-${PV}.tar.xz"
SRC_URI[sha256sum] = "8c68700c4e8355eddd1978ec721b983753380d2f7e57139ac7715e4122a764e8"

