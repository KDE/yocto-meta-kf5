# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kwallet-5.110.0.tar.xz"
SRC_URI[sha256sum] = "1f4fbbfcc157ca9cd59e85d358a839a49a25f4d5d7f6e2fde047efbf19f2e555"

