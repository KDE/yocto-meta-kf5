# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kwallet-5.84.0.tar.xz"
SRC_URI[sha256sum] = "6c58517faaacbddaffe6118ecd3e05b78c0cec5936824800cb3cd10f04c208d4"

