# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kwallet-5.85.0.tar.xz"
SRC_URI[sha256sum] = "e79816c79dd88d9700bd8517a1248dd5a95b5a8dd278948389a11535506c6d14"

