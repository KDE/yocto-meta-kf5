# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kwallet-5.86.0.tar.xz"
SRC_URI[sha256sum] = "8bf2454166bbc007893355ad0351fc40b0daa94b0402a14b9ffdb9859297ad1c"

