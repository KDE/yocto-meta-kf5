# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/kwallet-5.88.0.tar.xz"
SRC_URI[sha256sum] = "4ea69018f85f44472e77a76a6f5af180e60702f7e72a8e34f792d55729e255b8"

