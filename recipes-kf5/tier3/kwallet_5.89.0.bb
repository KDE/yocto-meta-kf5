# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/kwallet-5.89.0.tar.xz"
SRC_URI[sha256sum] = "3034db91605f287460420e4ce66bc8fa5f09076c8dfb2ed1895616aab422c3fb"

