# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/kwallet-5.90.0.tar.xz"
SRC_URI[sha256sum] = "74aa1144a358a1a43a133dabf1b0936ae01dc290e585573dec88e52d097ace19"

