# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kwallet-5.93.0.tar.xz"
SRC_URI[sha256sum] = "ed56f6477efb250b454f7b7861a16a5ea972487c1373647b7094047ce20fddeb"

