# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kwallet-5.94.0.tar.xz"
SRC_URI[sha256sum] = "01366b42754ee7543b67fe57deb39bc2a772923eda3e6ea70a59f8ef955e2a32"

