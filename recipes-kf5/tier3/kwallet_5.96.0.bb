# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kwallet-5.96.0.tar.xz"
SRC_URI[sha256sum] = "58066886622996a602568f6f92239e0e315593751a44d0c35ece987818084666"

