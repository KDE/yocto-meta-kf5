# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kwallet-5.98.0.tar.xz"
SRC_URI[sha256sum] = "4b699303b2b253fe09ef94acea2fb43051415d07645d799f9c9d7630699f9d4f"

