# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kwallet-5.99.0.tar.xz"
SRC_URI[sha256sum] = "d2c66b736872563a7ce4db5765325ecf5ec07c8f296e7160946bccefcce02a07"

