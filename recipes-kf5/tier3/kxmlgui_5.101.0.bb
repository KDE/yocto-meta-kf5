# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/kxmlgui-5.101.0.tar.xz"
SRC_URI[sha256sum] = "d5d559a211513ea5977b4efbabb89d4a53a74a7633086c3e8cc8e3231cfd9c7a"

