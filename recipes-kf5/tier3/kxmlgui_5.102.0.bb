# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/kxmlgui-5.102.0.tar.xz"
SRC_URI[sha256sum] = "37e72cb4ab8b6d1fa234328e25a1de99ffde65376a44d48c6705300d9134131a"

