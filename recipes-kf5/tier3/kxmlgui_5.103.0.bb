# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/kxmlgui-5.103.0.tar.xz"
SRC_URI[sha256sum] = "60df820035f039b551a9de833f256f607743f9afe8c9c885c7a29d6f00b26404"

