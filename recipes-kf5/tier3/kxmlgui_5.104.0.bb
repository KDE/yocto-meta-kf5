# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/kxmlgui-5.104.0.tar.xz"
SRC_URI[sha256sum] = "f45d5a5411b3ca0197c1e4720c27c7d85e351aeee03aca861066e8db3c7c93e6"

