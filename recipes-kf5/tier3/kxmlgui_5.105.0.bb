# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/kxmlgui-5.105.0.tar.xz"
SRC_URI[sha256sum] = "c17b9abed247728399bf4f1be599e9d33c3aeda41ced9590ec0eab0e4d1b4f68"

