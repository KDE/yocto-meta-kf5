# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/kxmlgui-5.107.0.tar.xz"
SRC_URI[sha256sum] = "4b4821804c3b3cd58dfe3cee474ee2999501d04f9936003a593bc64a3f1084e5"

