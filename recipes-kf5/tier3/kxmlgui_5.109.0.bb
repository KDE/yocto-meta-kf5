# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/kxmlgui-${PV}.tar.xz"
SRC_URI[sha256sum] = "b4094d33bfb381a07506ac0eb6844ecee3d45e63ab8596587fd0e883259adaee"

