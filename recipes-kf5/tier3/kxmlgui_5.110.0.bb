# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/kxmlgui-5.110.0.tar.xz"
SRC_URI[sha256sum] = "58766ebb700fa186f70a02ba374f895900a3e5b54fd0cdccc167ebd4a3281bc9"

