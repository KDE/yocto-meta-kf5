# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/kxmlgui-5.83.0.tar.xz"
SRC_URI[sha256sum] = "1be50b7dd9ada03754a64409ec678feede0ad9ca73dd978093ebbd552bf7c3d6"

