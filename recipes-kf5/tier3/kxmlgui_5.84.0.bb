# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/kxmlgui-5.84.0.tar.xz"
SRC_URI[sha256sum] = "2c3cbd25499dc51e45270c525a528efe16d26a07dc2047fa074708ceb9dcaeb5"

