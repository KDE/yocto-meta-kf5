# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/kxmlgui-5.85.0.tar.xz"
SRC_URI[sha256sum] = "253ae3984f2cc68165c683f5ac1f0a0417923d13673354e7ac8f156542cd3cb2"

