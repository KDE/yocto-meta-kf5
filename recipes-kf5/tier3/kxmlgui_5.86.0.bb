# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/kxmlgui-5.86.0.tar.xz"
SRC_URI[sha256sum] = "10dcee6b2e1a7808f9087861968c5918f43f8778e6e4b7b98069dfab3b9e1379"

