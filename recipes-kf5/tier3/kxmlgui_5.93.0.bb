# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/kxmlgui-5.93.0.tar.xz"
SRC_URI[sha256sum] = "74ba65d95fac0cd09cb66e14d199efc739e1a8c9aec25812f41cfc64d7f4b099"

