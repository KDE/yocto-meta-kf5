# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/kxmlgui-5.94.0.tar.xz"
SRC_URI[sha256sum] = "43a31730ff0ed113320817aa35a04e53b6ec647ab94320cf3b075adc38619dd6"

