# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/kxmlgui-5.96.0.tar.xz"
SRC_URI[sha256sum] = "33acae1c4814bf1b584608392a0a184ccb8b42c420c7ff057c95b0cb9f133fc2"

