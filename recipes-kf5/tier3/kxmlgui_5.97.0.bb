# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/kxmlgui-5.97.0.tar.xz"
SRC_URI[sha256sum] = "baf17929d6aabc11f6c9f8ac5402388846bf7c1d65d6896008c60d953218adf5"

