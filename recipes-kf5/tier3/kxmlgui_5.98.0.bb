# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/kxmlgui-5.98.0.tar.xz"
SRC_URI[sha256sum] = "857440cf53774786433967b47e27f509f322c9aca5bbccb1ea0ec0f9fea0c522"

