# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/kxmlgui-5.99.0.tar.xz"
SRC_URI[sha256sum] = "2c92c6cfffe57ccb9ccfda5fcfc60798e9138b0f639de5bf63a3c2e960f04adc"

