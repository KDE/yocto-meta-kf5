# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/portingAids/kxmlrpcclient-5.101.0.tar.xz"
SRC_URI[sha256sum] = "a2414cfc1438eb60301aa847b0242c9b50fa49714091bcbd2d0582c39479e88a"

