# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/portingAids/kxmlrpcclient-5.102.0.tar.xz"
SRC_URI[sha256sum] = "c42a98b4dcfb79e4ad042bb51f1dee94b8ff0b8d18309d831176e03447ec7219"

