# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/portingAids/kxmlrpcclient-5.103.0.tar.xz"
SRC_URI[sha256sum] = "e7f719019ccface5a69e3dba91e6307111fe2b24c12dc9f2bb8f513a43857693"

