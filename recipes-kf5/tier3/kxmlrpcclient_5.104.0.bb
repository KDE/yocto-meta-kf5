# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/portingAids/kxmlrpcclient-5.104.0.tar.xz"
SRC_URI[sha256sum] = "91a9ac7fd8c57bd66ad1f3abe935025b69e3fb4bc1fb555662b887a844bec3b5"

