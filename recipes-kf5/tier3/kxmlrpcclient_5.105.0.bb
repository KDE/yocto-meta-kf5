# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/portingAids/kxmlrpcclient-5.105.0.tar.xz"
SRC_URI[sha256sum] = "578dde6eaf873b7c6f554a5a8de2ae04a8e577cdf5a09b0e2e1867877d9c2cd0"

