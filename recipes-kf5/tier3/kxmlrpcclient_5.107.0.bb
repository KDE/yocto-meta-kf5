# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/portingAids/kxmlrpcclient-5.107.0.tar.xz"
SRC_URI[sha256sum] = "0cb214266c5a715c78f9b676ae4ff0f4fa1e502bf04ee0b855dae5c5275ecb79"

