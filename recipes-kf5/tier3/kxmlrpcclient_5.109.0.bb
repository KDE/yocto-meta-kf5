# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/portingAids/kxmlrpcclient-${PV}.tar.xz"
SRC_URI[sha256sum] = "b27584289fb89d9717862aaa780da072ffa272ebae0c46b72714cb9c4771d0b4"

