# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/portingAids/kxmlrpcclient-5.110.0.tar.xz"
SRC_URI[sha256sum] = "5ddf1227f49e9be2f0e248858ca336baa0e3f0676f398449e18b4821ab4aed3b"

