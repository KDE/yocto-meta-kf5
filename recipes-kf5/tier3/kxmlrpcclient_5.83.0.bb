# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/portingAids/kxmlrpcclient-5.83.0.tar.xz"
SRC_URI[sha256sum] = "916f8c243b54e70dc956a0e80c97de81b785c2d1bbc625c8e650062708d5c4dd"

