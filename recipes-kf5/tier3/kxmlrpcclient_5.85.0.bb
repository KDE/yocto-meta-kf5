# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/portingAids/kxmlrpcclient-5.85.0.tar.xz"
SRC_URI[sha256sum] = "a1196d626fba73c79a6c78470eb873a3ce0ab901696ed0751a21f8785cdbec84"

