# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/portingAids/kxmlrpcclient-5.86.0.tar.xz"
SRC_URI[sha256sum] = "d852eab538b2a2dc1921b9ebcd7b89a5f246a67a7d5e083440c550c7992f5b8d"

