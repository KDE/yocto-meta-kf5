# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/portingAids/kxmlrpcclient-5.88.0.tar.xz"
SRC_URI[sha256sum] = "679af4618fdb2f24f00de779f4430124bf8e0d8c7f447d05ede037806048800a"

