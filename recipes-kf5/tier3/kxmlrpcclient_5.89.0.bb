# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/portingAids/kxmlrpcclient-5.89.0.tar.xz"
SRC_URI[sha256sum] = "97424c10c9dbbf4f36d47c9357d429b77e69acda375720c7753bec90cdf92366"

