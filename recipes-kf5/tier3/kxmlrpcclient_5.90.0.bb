# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/portingAids/kxmlrpcclient-5.90.0.tar.xz"
SRC_URI[sha256sum] = "8cb23dc539fef71395947183c7c70a7a4c028086f2e8389b647a5b4ce2e30257"

