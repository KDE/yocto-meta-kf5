# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/portingAids/kxmlrpcclient-5.93.0.tar.xz"
SRC_URI[sha256sum] = "0cb41aff9f5660d95ee6d669f9c70692b55c089d0e1b9705e19b19fc2c49376c"

