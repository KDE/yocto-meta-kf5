# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/portingAids/kxmlrpcclient-5.94.0.tar.xz"
SRC_URI[sha256sum] = "65ac95cb022d5c7ca54c1e601211969aba06858773d881feb0004628a3451f82"

