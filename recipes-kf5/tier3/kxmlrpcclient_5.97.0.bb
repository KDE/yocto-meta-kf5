# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/portingAids/kxmlrpcclient-5.97.0.tar.xz"
SRC_URI[sha256sum] = "495a886b6bd134be578f37c0ad169a178f95dcbfd073e95d1579a0f493fbd309"

