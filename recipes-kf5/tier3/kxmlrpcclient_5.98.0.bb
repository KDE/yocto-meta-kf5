# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/portingAids/kxmlrpcclient-5.98.0.tar.xz"
SRC_URI[sha256sum] = "eb528dddf50fea450ee95680992357491512162e7149dff947fbeffd66765725"

