# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/plasma-framework-5.101.0.tar.xz"
SRC_URI[sha256sum] = "6ac9b4ded7d5f02a62aaafd23f1063258f0f2ae632490c4304765d7e545ed7fa"

