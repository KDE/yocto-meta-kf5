# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/plasma-framework-5.102.0.tar.xz"
SRC_URI[sha256sum] = "d3cdb52f82dfc66f689c44e97ab45dd0088d9062c92f30f9385cde05482c5491"

