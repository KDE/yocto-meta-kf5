# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/plasma-framework-5.103.0.tar.xz"
SRC_URI[sha256sum] = "a0b3cecce4f8bb22ad4ffb0d2f356b2efbdd9dc94d9b5f568dbd83a7431e8ae1"

