# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/plasma-framework-5.104.0.tar.xz"
SRC_URI[sha256sum] = "fa3bd51e1dc040079d9b4ea7b8b840846007624653a5ccb7dbbbf11ca580c55b"

