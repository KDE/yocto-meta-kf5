# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/plasma-framework-5.105.0.tar.xz"
SRC_URI[sha256sum] = "5311778e9b3ea896a245d9a80554a94b30b5e1d130732d2f4a912c0f27243ca7"

