# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/plasma-framework-5.107.0.tar.xz"
SRC_URI[sha256sum] = "6053a55a498ebefd4cd468365acc46e1287066bb17398ec9f3d68aaf2abf0f2a"

