# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/plasma-framework-${PV}.tar.xz"
SRC_URI[sha256sum] = "610ed1c136ed9b9a403c09821cbc886a8a1103aece23119f47b6a0a43c00198d"

