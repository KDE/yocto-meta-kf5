# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/plasma-framework-5.110.0.tar.xz"
SRC_URI[sha256sum] = "8e1d7055f2c590f40e70620cc67311cfc8560d2f325e44219e96d59f29b2d449"

