# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/plasma-framework-5.84.0.tar.xz"
SRC_URI[sha256sum] = "19b5cc632a2e79c28caeea36fdf9e1cc47c1ee1d7c1dc3432378854ac0aa1532"

