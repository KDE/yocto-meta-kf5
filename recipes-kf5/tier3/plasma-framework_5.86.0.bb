# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/plasma-framework-5.86.0.tar.xz"
SRC_URI[sha256sum] = "304715e0261370a97bc15b8fc57f2d4b9145787ba133fbdd078308c031eeae9d"

