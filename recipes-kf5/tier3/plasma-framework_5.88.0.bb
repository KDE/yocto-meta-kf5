# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/plasma-framework-5.88.0.tar.xz"
SRC_URI[sha256sum] = "9640040242aaacd1017b993e23426449ee71ba7b54ac5ce7e042e5d5aca301a8"

