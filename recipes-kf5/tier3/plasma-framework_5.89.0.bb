# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/plasma-framework-5.89.0.tar.xz"
SRC_URI[sha256sum] = "b709a8effe04f12f4c04c65c185e09ee7479477b505283ae70d5d1fbd450a673"

