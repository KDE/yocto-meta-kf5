# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/plasma-framework-5.93.0.tar.xz"
SRC_URI[sha256sum] = "d4a2c687ea2ea8dfe7c256eb58441fc458102ed4b445dc24685513dd96b5c322"

