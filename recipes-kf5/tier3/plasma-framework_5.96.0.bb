# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/plasma-framework-5.96.0.tar.xz"
SRC_URI[sha256sum] = "0236ea39448299d9c861cf8da2582baeec7ccfd4660406c47abec70bcedebe92"

