# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/plasma-framework-5.97.0.tar.xz"
SRC_URI[sha256sum] = "73987d498bd231d984dbaad9fb94e38e32441635464ffeacbfcd089a7695b527"

