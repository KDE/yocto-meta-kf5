# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/plasma-framework-5.98.0.tar.xz"
SRC_URI[sha256sum] = "e4e1585d949533dea69bf57f7aa0d1d40e9305fa0b5006315a760179c1dcbcae"

