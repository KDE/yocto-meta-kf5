# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/plasma-framework-5.99.0.tar.xz"
SRC_URI[sha256sum] = "93eda884a00380b07ebdd5eedd6423ab48ffa031fbe16b1e239b550b7412a0ab"

