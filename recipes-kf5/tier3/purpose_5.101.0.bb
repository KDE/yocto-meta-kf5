# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/purpose-5.101.0.tar.xz"
SRC_URI[sha256sum] = "b3afa707f89d2c4ac4358780348ec5e32e51355b546f13fa589adf5b00c2b117"

