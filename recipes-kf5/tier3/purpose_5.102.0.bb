# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/purpose-5.102.0.tar.xz"
SRC_URI[sha256sum] = "3c82b33be6946756a0c2e2d177c03c9c8bee0ca36802e8b07aa3bf464fb7a0a8"

