# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/purpose-5.103.0.tar.xz"
SRC_URI[sha256sum] = "f308bdfc3410101468f36e5a08ee055154cf0414fb2b2db7ba569b34afdb002a"

