# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/purpose-5.104.0.tar.xz"
SRC_URI[sha256sum] = "086e9a0f70d1740f50e7dcb1593ec3a0cd8edfe9425aa90ce3f02bd0ed3f2ec1"

