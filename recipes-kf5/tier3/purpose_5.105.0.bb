# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/purpose-5.105.0.tar.xz"
SRC_URI[sha256sum] = "b89fca5d4ea18b6c9323a90c0cacc85d7f2c95a5ef087de0d69154f698104f16"

