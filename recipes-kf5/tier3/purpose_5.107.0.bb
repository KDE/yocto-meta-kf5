# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/purpose-5.107.0.tar.xz"
SRC_URI[sha256sum] = "99cdf31a52b606ff6ee25acec1ee030e52e0c004d3fd3a42b2bba838473f9d2c"

