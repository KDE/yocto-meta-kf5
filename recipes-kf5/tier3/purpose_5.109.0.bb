# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/purpose-${PV}.tar.xz"
SRC_URI[sha256sum] = "31335b2fa3d502d8d8474e67f2f1a671e9ea3693b290a6ff57b93b047afdcc12"

