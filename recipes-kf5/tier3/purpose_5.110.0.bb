# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/purpose-5.110.0.tar.xz"
SRC_URI[sha256sum] = "4ce763bec127bbdd1cb2526a4d615ab6f420ab2c2a700cb09571b0220fc4865a"

