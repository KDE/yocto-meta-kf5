# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.83/purpose-5.83.0.tar.xz"
SRC_URI[sha256sum] = "02d01a386a4ebbfe5919a54a9442184c5c571213b4a2c98252d94fbc47040369"

