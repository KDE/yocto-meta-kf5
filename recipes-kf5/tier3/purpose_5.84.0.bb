# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.84/purpose-5.84.0.tar.xz"
SRC_URI[sha256sum] = "67bb7d2a31ede9ab059b50a9f3ed7b53050060662b0bde29a08f30c25c413007"

