# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/purpose-5.85.0.tar.xz"
SRC_URI[sha256sum] = "c5817a400aa531a3e5f5fbdadc4b350cbdc6286f2983a341db0d3b1cd03b248f"

