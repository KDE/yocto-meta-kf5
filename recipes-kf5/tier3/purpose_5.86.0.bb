# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/purpose-5.86.0.tar.xz"
SRC_URI[sha256sum] = "6722e6fbef07d57742951a15dd2b7e8235a72aebc48b1e26df2721633d8cbba3"

