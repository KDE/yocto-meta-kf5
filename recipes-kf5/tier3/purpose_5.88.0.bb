# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/purpose-5.88.0.tar.xz"
SRC_URI[sha256sum] = "374506aff7b54cbd3cec87c0d8782bf896f573548b3b689224e2bd8b38b148a2"

