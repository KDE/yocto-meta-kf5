# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/purpose-5.89.0.tar.xz"
SRC_URI[sha256sum] = "9ed384ef4527d33b98bd2865cd744da694e6abc8e0e7e9c8f321c317f8e7d0e9"

