# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/purpose-5.90.0.tar.xz"
SRC_URI[sha256sum] = "810ae4e77d0206649a3f56cf69e6c76b867a7c774d3dc7cf0cbed521a14941a0"

