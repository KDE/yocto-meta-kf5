# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/purpose-5.93.0.tar.xz"
SRC_URI[sha256sum] = "dc0bc0c7c5d9b27e21856132ceeb3893555a36f3944ebc97da2eb76a74e92cc4"

