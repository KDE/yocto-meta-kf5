# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/purpose-5.94.0.tar.xz"
SRC_URI[sha256sum] = "73adff977f2a69624abaf6340d6609dde41f404600feb28e51e1c7db4541b3ab"

