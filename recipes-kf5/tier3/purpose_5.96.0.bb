# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/purpose-5.96.0.tar.xz"
SRC_URI[sha256sum] = "7940d70bb6f9ef6fcd9af621096bccb2622680cffcb681ea0b312ec6741b513e"

