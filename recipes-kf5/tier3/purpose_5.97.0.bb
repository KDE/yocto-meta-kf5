# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/purpose-5.97.0.tar.xz"
SRC_URI[sha256sum] = "83fed8d56231a11fc1e39a04aef8caf84408c51a5806b633bf18895d5481519f"

