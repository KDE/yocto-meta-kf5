# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/purpose-5.98.0.tar.xz"
SRC_URI[sha256sum] = "d97a2914526b746c84e2e198b7584df4c236d7c9a37272f1f083b664359c3e3d"

