# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/purpose-5.99.0.tar.xz"
SRC_URI[sha256sum] = "1e9f30b4da3a5751423ed4e1e3cd76ec6d103ab485d859362e29273858ce02ae"

