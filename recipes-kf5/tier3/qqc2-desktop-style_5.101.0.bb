# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/qqc2-desktop-style-5.101.0.tar.xz"
SRC_URI[sha256sum] = "a19ceb8a7e86290a5891145a043c2dfbeb2cda2404d93559ff2b6c98bb9adf06"

