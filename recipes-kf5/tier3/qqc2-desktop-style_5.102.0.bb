# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/qqc2-desktop-style-5.102.0.tar.xz"
SRC_URI[sha256sum] = "d8f1bfeb59d1ead7f5d42a97614c92e5527802639e995f5432d57e4ab07bd5b0"

