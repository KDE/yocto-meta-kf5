# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/qqc2-desktop-style-5.103.0.tar.xz"
SRC_URI[sha256sum] = "f18eba0ca9e6f5e2133c7108ee2c48243c498112d4d6dceeecf8a63d17b728a5"

