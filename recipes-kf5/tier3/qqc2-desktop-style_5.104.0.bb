# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/qqc2-desktop-style-5.104.0.tar.xz"
SRC_URI[sha256sum] = "9a72ee9f0a85b5ddd0c135fb7260689e6687880966f96cc77afef5169ec4febc"

