# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/qqc2-desktop-style-5.105.0.tar.xz"
SRC_URI[sha256sum] = "de8f6c8b6a9af2caecfea20f71d84a791e6f685b8b6048668ed22a0d25121a92"

