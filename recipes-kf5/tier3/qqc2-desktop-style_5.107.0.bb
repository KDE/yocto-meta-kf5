# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/qqc2-desktop-style-5.107.0.tar.xz"
SRC_URI[sha256sum] = "5cb96c9799f0fb46b9bf3826121ae00e31955591b255e50e83f1437178f1f242"

