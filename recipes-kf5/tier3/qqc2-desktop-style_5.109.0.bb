# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/qqc2-desktop-style-${PV}.tar.xz"
SRC_URI[sha256sum] = "700ebade1fdc07c317259a7eb8e2cfdb67f9f47845d32a3238fea3c974990c3b"

