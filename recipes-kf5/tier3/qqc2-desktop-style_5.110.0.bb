# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/qqc2-desktop-style-5.110.0.tar.xz"
SRC_URI[sha256sum] = "6f3c2f73b283c7373b695f33eaa2479349dae135fdba2efd04fcab843285fe12"

