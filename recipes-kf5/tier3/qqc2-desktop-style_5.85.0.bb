# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/qqc2-desktop-style-5.85.0.tar.xz"
SRC_URI[sha256sum] = "b70539f9f3b222e892ec1d25feab843ccad8004647cc24abedd361f5dbf06cc2"

