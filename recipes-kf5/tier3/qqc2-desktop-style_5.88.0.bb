# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/qqc2-desktop-style-5.88.0.tar.xz"
SRC_URI[sha256sum] = "a2f4afa088a81b6e9367c08c341e721d4a92832ff26b0889ae3566f37247445f"

