# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/qqc2-desktop-style-5.89.0.tar.xz"
SRC_URI[sha256sum] = "ac5089295a0affd0e0abef737265b318b2ab3ad888df45b56a74b86416045ee0"

