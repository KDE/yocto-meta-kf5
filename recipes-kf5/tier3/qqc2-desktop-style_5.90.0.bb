# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/qqc2-desktop-style-5.90.0.tar.xz"
SRC_URI[sha256sum] = "1921b1c56556c6ff6c53ef081199d5306bb9488f5457247eacd646d09bcfe115"

