# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/qqc2-desktop-style-5.93.0.tar.xz"
SRC_URI[sha256sum] = "161ec085a529e23532badb7723c78051e7b4c3a3fe11d3c4ab8bab93213ba9a8"

