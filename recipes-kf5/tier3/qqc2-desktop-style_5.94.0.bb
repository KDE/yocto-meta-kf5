# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/qqc2-desktop-style-5.94.0.tar.xz"
SRC_URI[sha256sum] = "0b15210dbe93c22e423c876b27ca2f530f66cb72c6c5bcc7f854848ded0e7e48"

