# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/qqc2-desktop-style-5.96.0.tar.xz"
SRC_URI[sha256sum] = "087d2a38a52a96fd3cf6662fa31a7500f3251847f5bf5185b2496b4e46dbc939"

