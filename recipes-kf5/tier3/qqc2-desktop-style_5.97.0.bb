# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/qqc2-desktop-style-5.97.0.tar.xz"
SRC_URI[sha256sum] = "466967eec3b10a3e0eb0c2e1f09b9c23ff0f08399563d112c7bec26061f134a6"

