# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/qqc2-desktop-style-5.98.0.tar.xz"
SRC_URI[sha256sum] = "edf4460e9431a7eb52c3595e2acea1fbc405387bdc06f7ec6f408849da8fc7a9"

