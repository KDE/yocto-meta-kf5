# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.99/qqc2-desktop-style-5.99.0.tar.xz"
SRC_URI[sha256sum] = "bd39f9765a2963a85f7083dfe8a55b615a89cc5aeda07220b4ceba98fc9efea6"

