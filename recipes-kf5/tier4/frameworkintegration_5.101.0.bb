# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.101/frameworkintegration-5.101.0.tar.xz"
SRC_URI[sha256sum] = "6c52b56140ab79ad38e4a3a32a7765a3c955476d46208a821cb1ed3b3f6fb47c"

