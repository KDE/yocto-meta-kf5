# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.102/frameworkintegration-5.102.0.tar.xz"
SRC_URI[sha256sum] = "2d80cac9a154a679b7a4186504e9b3ca792ecc29925e62fc1ef5390489351903"

