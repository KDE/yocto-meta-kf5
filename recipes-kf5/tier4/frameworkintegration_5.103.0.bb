# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.103/frameworkintegration-5.103.0.tar.xz"
SRC_URI[sha256sum] = "23f1937da5a15a909baea1827d49fedf2d3073121a0a2c7a4482db6c136492be"

