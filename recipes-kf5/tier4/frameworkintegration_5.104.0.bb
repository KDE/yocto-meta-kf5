# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.104/frameworkintegration-5.104.0.tar.xz"
SRC_URI[sha256sum] = "51c8074517dc0d03c1cc199d68272c73a3d8f636722473d298b3030d9f38b9e8"

