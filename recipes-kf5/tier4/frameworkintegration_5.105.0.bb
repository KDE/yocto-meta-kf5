# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/frameworkintegration-5.105.0.tar.xz"
SRC_URI[sha256sum] = "253a7733505aa99db7dfa7accd3ed416582251b39aeead136a943945619aaf71"

