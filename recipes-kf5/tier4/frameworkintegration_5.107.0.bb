# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.107/frameworkintegration-5.107.0.tar.xz"
SRC_URI[sha256sum] = "f81816aa86002d9d7053040241faab153873278c89588032eab1954d2451aa48"

