# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.109/frameworkintegration-${PV}.tar.xz"
SRC_URI[sha256sum] = "9d4d1f1b6f18110d8f11542f7aaa8a60397fdefcb1b7ca9f0a79a125e4624427"

