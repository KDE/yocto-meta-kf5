# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.110/frameworkintegration-5.110.0.tar.xz"
SRC_URI[sha256sum] = "58837f80e86ad1d18cfcc6cdb94146e9020a16c15cfacfcb914d8e17c02d143e"

