# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.85/frameworkintegration-5.85.0.tar.xz"
SRC_URI[sha256sum] = "f9d799b70f1c8ae661775c0a968e459bff8c5411567856075ac143573c0c77c8"

