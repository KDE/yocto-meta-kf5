# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.86/frameworkintegration-5.86.0.tar.xz"
SRC_URI[sha256sum] = "d44677cc3dff45584ab0fef72671a16dc0b45382dcb408e56c094f5feb352669"

