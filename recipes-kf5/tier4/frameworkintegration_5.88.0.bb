# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.88/frameworkintegration-5.88.0.tar.xz"
SRC_URI[sha256sum] = "423b05d84364956cac1eaa01669aa25db6a78ad46f8557eb2766e326d7bf4191"

