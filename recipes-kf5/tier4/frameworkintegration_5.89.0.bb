# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.89/frameworkintegration-5.89.0.tar.xz"
SRC_URI[sha256sum] = "4e241eaced12a5a41c4eb72e1c7a1ae8cca5bdc22e6ea41cb22472fb6ac7ec38"

