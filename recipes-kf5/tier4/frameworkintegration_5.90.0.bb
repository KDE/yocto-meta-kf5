# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.90/frameworkintegration-5.90.0.tar.xz"
SRC_URI[sha256sum] = "5651afb5bb3563d2212662974bd91750b313e3b58fabf59f59459ef904a6fbec"

