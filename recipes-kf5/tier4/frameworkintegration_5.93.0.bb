# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.93/frameworkintegration-5.93.0.tar.xz"
SRC_URI[sha256sum] = "156e54c9ee679bda943a279c28c6a834ca02e991b3f53a1b92f8c3931388a2a6"

