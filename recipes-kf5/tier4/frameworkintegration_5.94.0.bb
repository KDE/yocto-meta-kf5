# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.94/frameworkintegration-5.94.0.tar.xz"
SRC_URI[sha256sum] = "9a64abebf8d242765ae759611fc9819a03403047ed56b8dd71aba7a0bbb4faa6"

