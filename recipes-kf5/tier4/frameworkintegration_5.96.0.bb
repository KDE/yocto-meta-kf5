# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.96/frameworkintegration-5.96.0.tar.xz"
SRC_URI[sha256sum] = "69bece6b66542cfd3985046af1f63174ed909e34fe5a3c972506e250a0c1f1a6"

