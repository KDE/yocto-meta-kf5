# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.97/frameworkintegration-5.97.0.tar.xz"
SRC_URI[sha256sum] = "3b6822538383ae4a152498c09024c02c03c97742e40a1fe3bdb08eb5ed4332eb"

