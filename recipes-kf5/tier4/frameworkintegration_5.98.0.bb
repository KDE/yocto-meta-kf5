# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.98/frameworkintegration-5.98.0.tar.xz"
SRC_URI[sha256sum] = "d8c4ebed8cf573daa6916f089d596ab345cbbf5016c379a525155224e5b32ad7"

