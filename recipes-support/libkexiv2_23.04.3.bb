require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkexiv2-${PV}.tar.xz"
SRC_URI[sha256sum] = "949550f0d7d41172b59f7000010b7e6c2acaaddade2f6139cfca5fb2143b8b99"
