# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "7162739b07450957fc27fe9859b55e98bbd77f92"
